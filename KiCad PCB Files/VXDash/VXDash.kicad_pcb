# Repository martinroger/VXDash (continued)

## KiCad design KiCad PCB Files/VXDash/VXDash.kicad_pcb (continued)

Parts:
C57: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 10V; LCSC C19702
D10: SP0503BAHTG; SOT-143; LCSC C7074
D11: 1N5819HW-7-F; D_SOD-123; LCSC C82544
J7: USB4105-GF-A; GCT_USB4105-GF-A; LCSC C3020560
R85, R87: 5.1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C105580
R86: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C21189

Connections:
/USBC/VBUS: D10.2 (K), D11.2, J7.A4_B9 (VBUS), J7.B4_A9 (VBUS__1); also elsewhere on the board
/USBC/VCC_5V: C57.2, D11.1; also elsewhere on the board
/USB_DN: D10.4 (K), J7.A7 (DN1), J7.B7 (DN2); also elsewhere on the board
/USB_DP: D10.3 (K), J7.A6 (DP1), J7.B6 (DP2); also elsewhere on the board
GND: C57.1, D10.1 (A), J7.A1_B12 (GND), J7.B1_A12 (GND__1), R85.1, R86.1, R87.2; also elsewhere on the board
unnamed: J7.A5 (CC1), R85.2
unnamed: J7.B5 (CC2), R87.1
unnamed: J7.SH1 (SHELL_GND), J7.SH2 (SHELL_GND__1), J7.SH3 (SHELL_GND__2), J7.SH4 (SHELL_GND__3), R86.2

Parts:
D25: BAT54; D_SOD-123; LCSC C152458
JP6: EN LOAD EMU; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R111: 680R; R_1210_3225Metric_Pad1.30x2.65mm_HandSolder; LCSC C163351
R112: 47R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114623
R113: 15R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C128059

Connections:
AIRBAG_ActLO: R113.2; also elsewhere on the board
unnamed: D25.2 (A), JP6.1 (A)
unnamed: D25.1 (K), R111.1
unnamed: R111.2, R112.1
unnamed: R112.2, R113.1
Protected_12V: JP6.2 (B); also elsewhere on the board

Notes on the sheet:
Approximately calculated for 17mA drop at 13V feed Vf @20mA is approximately 0.38V Vf @10mA is approximately 0.35V 13-0.38 = 12,62V and 12.62/742 = 17mA 13-0.35 = 12.65V and 12.65/742 = 17,04mA

Schematic: Buzzer.kicad_sch

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6; LCSC C49246932
D33: BAT54; D_SOD-123; LCSC C152458
Q8: PJA3441; SOT-23; LCSC C313504
R140: 22R; R_0805_2012Metric; LCSC C107702
R141: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C98220

Connections:
DOOR_ActLO: BZ1.2 (-); also elsewhere on the board
IGNITION_ActHI: R141.1; also elsewhere on the board
L_BEAM_ActHI: Q8.2 (S); also elsewhere on the board
unnamed: BZ1.1 (+), R140.2
unnamed: D33.2 (A), Q8.3 (D)
unnamed: D33.1 (K), R140.1
unnamed: Q8.1 (G), R141.2

Notes on the sheet:
BUZZER ON when IGNITION == Low, DOOR == Low (open), Low Beams == High Low beams - Fed by the low beam lights relay. Either 12V or floating(extra ~20mA is negligible to drive a buzzer) Ign - Taken from main power/ignition control FET gate control (pulldown on POWER_INPUT sch). ~{Door} - Only low if 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
Self-driven sounder. Typically ~20-50mA. 9.5mm height.

Schematic: pulsed_sig_proc.kicad_sch, PWM signal cleaning and processing

Parts:
C63, C64: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C16194176
C65, C66, C67: 1n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C100040
D34, D35, D36: BAT54SW; SOT-323_SC-70; LCSC C78606
IC8: CD74HC4050M96; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C131932
R143, R144, R145: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C98220
R146, R147, R148: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C14675
R149, R150, R151: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C2906981
U20: 40106; SO-14_3.9x8.65mm_P1.27mm; LCSC C443841

Connections:
+3V3: C63.1, IC8.1 (VCC); also elsewhere on the board
/Pulsed signals processing/rpm_clean: R148.1, R151.1, U20.6
/Pulsed signals processing/speed_clean: R147.1, R150.1, U20.4
/Pulsed signals processing/water_clean: R146.1, R149.1, U20.2
/rpm: IC8.2 (1Y); also elsewhere on the board
/speed: IC8.4 (2Y); also elsewhere on the board
/water_T: IC8.6 (3Y); also elsewhere on the board
GND: C63.2, C64.2, C65.2, C66.2, C67.2, D34.1 (A), D35.1 (A), D36.1 (A), IC8.8 (GND), IC8.9 (4A), IC8.11 (5A), IC8.14 (6A), R146.2, R147.2, R148.2, U20.7 (VSS); also elsewhere on the board
unnamed: C66.1, D34.3 (COM), R144.1, U20.13
unnamed: C67.1, D35.3 (COM), R145.1, U20.9
unnamed: C65.1, D36.3 (COM), R143.1, U20.11
unnamed: IC8.3 (1A), R151.2
unnamed: IC8.5 (2A), R150.2
unnamed: IC8.7 (3A), R149.2
unnamed: U20.1, U20.12
unnamed: U20.5, U20.8
unnamed: U20.3, U20.10
Protected_12V: C64.1, D34.2 (K), D35.2 (K), D36.2 (K), U20.14 (VDD); also elsewhere on the board
RPM_HALL: R145.2; also elsewhere on the board
SPEED_HALL: R143.2; also elsewhere on the board
WATER_T_PWM: R144.2; also elsewhere on the board

Notes on the sheet:
10kOhm for diode protection Forms a RC filter Cut-off frequency : - For 1nF -> 16kHz - For 10nF -> 1.6kHz 1nF and below seems preferable to avoid distortion
Possible references : CD40106BM96 -> SOIC 14 HCF40106YM013TR -> SO 14 CD40106BPWR -> TSSOP 14
Double inversion to maintain current SW logic

Schematic: Power_Input.kicad_sch, Ignition and power protection

Parts:
C44, C45, C49: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C16194176
C46, C47, C48: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 25V; LCSC C14860
D8, D9: 18V; D_SOD-123; LCSC C668896
D12: BATT12V_ON; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C157740; not fitted
F1: 30R250UPR; Fuse_BelFuse_0ZRE0033FF_L11.4mm_W3.8mm; LCSC C207101
FB1: 120R@100MHz; L_0805_2012Metric; LCSC N/A
Q5: 2N7002; SOT-23; LCSC C78712
Q6, Q7: PJA3441; SOT-23; LCSC C313504
R77: 30k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C126352
R78, R79: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C98220
R80: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C14675
R99: 3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C126358; not fitted
RV1: MOV-07D220K; RV_Disc_D9mm_W3.5mm_P5mm; LCSC C1528486

Connections:
/POWER INPUT/Power_Mid: D9.1 (K), Q6.2 (S), Q7.2 (S), R80.1
/POWER INPUT/Power_Pre-Filter: C46.2, FB1.1, Q7.3 (D)
BATT12V+: F1.1; also elsewhere on the board
GND: C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, D8.2 (A), D12.1 (K), Q5.2 (S), R78.2, RV1.1; also elsewhere on the board
IGNITION_ActHI: R77.1; also elsewhere on the board
unnamed: C45.2, D8.1 (K), Q5.1 (G), R77.2, R78.1
unnamed: D9.2 (A), Q6.1 (G), Q7.1 (G), R79.2, R80.2
unnamed: D12.2 (A), R99.2
unnamed: Q5.3 (D), R79.1
unnamed: C44.2, F1.2, Q6.3 (D), RV1.2
Protected_12V: C47.2, C48.2, C49.2, FB1.2; also elsewhere on the board

Notes on the sheet:
PJA3441 40V Vds max 3.1A max Vgs-th 2.5V max 88mOhm max +-20V Vgs max
Voltage spike protection. Automotive 12V supply can see spikes >60V due to load-dump, etc. Varistor 18V max working, 24V max clamping 250A.
0ZRB0250FF1E 2.5A Hold max 5A trip 10.3s time-to-trip

Schematic: 5V_SMPS.kicad_sch, 5V SMPS

Parts:
C13: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 25V; LCSC C14860
C14, C15, C17: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C16194176
C16: 22p; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder; Voltage 50V; LCSC C1882706; not fitted
C18, C19: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 10V; LCSC C87996
IC2: AP62200; TSOT-23-6_HandSoldering; LCSC C1323282
L1: 4u7; Ind_5050; LCSC C2838218
R7: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22548
R8: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C14675
R9: 43k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C137719
R10: 8k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114637

Connections:
+5V: C16.1, C17.2, C18.1, C19.1, L1.2, R9.1; also elsewhere on the board
/5V_SMPS/5V_FB: C16.2, IC2.4 (FB), R9.2, R10.1
/5V_SMPS/5V_SW: C15.1, IC2.2 (SW), L1.1
/5V_enable: R7.1; also elsewhere on the board
GND: C13.1, C14.1, C17.1, C18.2, C19.2, IC2.1 (GND), R8.2, R10.2; also elsewhere on the board
unnamed: C15.2, IC2.6 (BST)
unnamed: IC2.5 (EN), R7.2, R8.1
Protected_12V: C13.2, C14.2, IC2.3 (VIN); also elsewhere on the board

Parts of its further copies:
C2: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 25V; LCSC C14860
C3, C4, C6: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C16194176
C5: 22p; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder; Voltage 50V; LCSC C1882706; not fitted
C51, C52: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 10V; LCSC C87996
IC5: AP62200; TSOT-23-6_HandSoldering; LCSC C1323282
L3: 4u7; Ind_5050; LCSC C2838218
R81: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22548
R82: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C14675
R83: 43k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C137719
R84: 8k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114637

Connections of its further copies:
+5V_AUX: C5.1, C6.2, C51.1, C52.1, L3.2, R83.1; also elsewhere on the board
/5V_SMPS_AUX/5V_FB: C5.2, IC5.4 (FB), R83.2, R84.1
/5V_SMPS_AUX/5V_SW: C4.1, IC5.2 (SW), L3.1
/5V_aux_enable: R81.1; also elsewhere on the board
GND: C2.1, C3.1, C6.1, C51.2, C52.2, IC5.1 (GND), R82.2, R84.2; also elsewhere on the board
unnamed: C4.2, IC5.6 (BST)
unnamed: IC5.5 (EN), R81.2, R82.1
Protected_12V: C2.2, C3.2, IC5.3 (VIN); also elsewhere on the board

Notes on the sheet:
Vfb = 0.8V, +/-2% w.c. Rtop = 43k, Rbtm = 8k2 4.995V out typ. min ~4.86V, max ~5.12V

Schematic: Rsensing_Pair.kicad_sch, Rsensing subcircuit

Parts:
C27: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C16194176
C28, C29: 33n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C106856
D1, D2, D3, D4: BAT54; D_SOD-123; LCSC C152458
IC4: AS2333_OpAmp; MSOP-8_3x3mm_P0.65mm; LCSC C5948553
Q1, Q2, Q3, Q4: DMP3099L; SOT-23; LCSC C155244
R47, R48, R54, R55: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22548
R49, R56: 18R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C245924
R50, R57: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C21189
R51, R58: 1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; LCSC C131398
R52, R59: 160R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C185369
R53, R60: 6R8; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C23214

Connections:
+3V3: C27.2, D2.1 (K), D4.1 (K), IC4.8, R49.2, R52.2, R56.2, R59.2; also elsewhere on the board
/ANALOGUE/Rsensing_Pair1/ADC_B: C29.2, D4.2 (A), R58.2
/ANALOGUE/Rsensing_Pair1/HighResiSet_B: R55.1
/ANALOGUE/Rsensing_Pair1/Sender_B: D3.1 (K), R58.1
/ANALOGUE/r_adc_1: C28.2, D2.2 (A), R51.2; also elsewhere on the board
/ANALOGUE/v_ref: IC4.3 (+), IC4.5 (+); also elsewhere on the board
/Set_Hi_Chan_A: R48.1; also elsewhere on the board
FUEL_LVL_Rsense: D1.1 (K), R51.1; also elsewhere on the board
GND: C27.1, C28.1, C29.1, IC4.4; also elsewhere on the board
unnamed: D1.2 (A), Q2.3 (D)
unnamed: D3.2 (A), Q4.3 (D)
unnamed: IC4.1, R47.1
unnamed: IC4.7, R54.1
unnamed: IC4.2 (-), Q2.2 (S), R50.1
unnamed: IC4.6 (-), Q4.2 (S), R57.1
unnamed: Q1.3 (D), R50.2, R53.1
unnamed: Q1.1 (G), R48.2
unnamed: Q1.2 (S), R49.1
unnamed: Q2.1 (G), R47.2
unnamed: Q3.3 (D), R57.2, R60.1
unnamed: Q3.1 (G), R55.2
unnamed: Q3.2 (S), R56.1
unnamed: Q4.1 (G), R54.2
unnamed: R52.1, R53.2
unnamed: R59.1, R60.2

Notes on the sheet:
Place cap near ADC
Zener required on the 3V3 rail. Put Zener closer to the Rsensing circuits.
ADC range 2.7V. Allows for reasonable voltage drop across current source and diode. 300R and 3k max sensor resistance per range. Low range = 2.7 / 300 = 9mA, High range = 2.7 / 3k = 900uA. 150mV Vref. Low range = 150mV / 9mA = 16.666 ohm High range 150mV / 900uA = 166.666 ohm High range = 160R + 6R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

Board: 4 copper layers, 186.0 x 74.5 mm, 266 parts (246 on the bottom side), 175 nets.

## KiCad design KiCad PCB Files/VXDash_Connectors/VXDash_Connectors.kicad_pcb

Board: 2 copper layers, 27.5 x 112.5 mm, 5 parts (0 on the bottom side), 25 nets, no tracks yet.

Parts:
H1, H2: M4 Thread mount; KEYSTONE_7765
J1: Header_VX220_RightAngle; Aptiv 12092886
J3: Passthrough; IDC-Header_2x15_P2.54mm_Vertical
J4: CANbus; TE_DTF13-4P

Connections:
/ABS_ActLO: J1.B12 (ABS), J3.28
/AIRBAG_ActLO: J1.B4 (Airbag), J3.12
/ALARM: J1.B7 (Alarm), J3.18
/ALTERN_ActLO: J1.A10 (Alternator), J3.19
/BATT12V+: J1.A1 (12V), J3.1, J3.2
/BRAKE_ActLO: J1.B1 (Brake_Fluid), J3.6
/BTN_ActLO: J1.B9 (Dash_Button), J3.22
/CAN_H: J3.30, J4.3
/CAN_L: J3.29, J4.2
/COOLANT_ActLO: J1.B10 (Coolant_Level), J3.24
/DOOR_ActLO: J1.B11 (Door_Switch), J3.26
/FUEL_LVL_Rsense: J1.A7 (Fuel_level), J3.13
/H_BEAM_ActHI: J1.A9 (Hi_Beam), J3.17
/IGNITION_ActHI: J1.A3 (Ignition), J3.5, J4.4
/IMMO_ActLO: J1.B5 (Immobiliser), J3.14
/L_BEAM_ActHI: J1.B6 (Low_Beam), J3.16
/L_TURN_ActHI: J1.A11 (Left_Indicator), J3.21
/OIL_ALRM_ActLO: J1.B3 (Oil_Pressure), J3.10
/PARK_ActLO: J1.B2 (Parking_Brake), J3.8
/RPM_HALL: J1.A4 (RPM), J3.7
/R_TURN_ActLO: J1.A12 (Right_Indicator), J3.23
/SPARE_B8: J1.B8 (?), J3.20
/SPEED_HALL: J1.A5 (Speed), J3.9
/WATER_T_PWM: J1.A6 (Water_Temp), J3.11
GND: H1.MP, H2.MP, J1.A2 (0V), J3.3, J3.4, J3.27, J4.1

## KiCad design KiCad PCB Files/VXDash_Emulator_lite/VXDash_Emulator.kicad_pcb

Board: 4 copper layers, 152.0 x 74.0 mm, 365 parts (1 on the bottom side), 218 nets.

Parts:
C1, C2, C4, C5, C7, C11, C12, C14, C17, C18, C22: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C10, C19, C20, C21: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C6, C13: 22p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C9, C15, C16: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1: ~{ledc_chan_2_ON}; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: ~{ledc_chan_1_ON}; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: BATT_ON; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: ~{ledc_chan_0_ON}; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: 5V_ON; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6: 3V3_ON; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D7: IGN_ON; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8: PROT12V ON; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D9, D11, D13, D15, D17, D19, D21, D23, D25, D27, D29, D31, D33, D35, D38, D40: Out Hi; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D10, D12, D14, D16, D18, D20, D22, D24, D26, D28, D30, D32, D34, D36, D37, D39: Out Lo; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D41, D42, D43, D44, D45, D46, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58: ResON; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D47, D48: 18V; D_SOD-123
F1: 0ZRB0250FF1E; Fuse_BelFuse_0ZRE0033FF_L11.4mm_W3.8mm
FB1: 120R@100MHz; L_0805_2012Metric
H1, H2: MountingHole_Pad; MountingHole_3.5mm_Pad
IC1, IC2: AP62200; TSOT-23-6_HandSoldering
J1: Car 24P Connector; PinHeader_2x12_P2.54mm_Vertical
J2, J3, J5: Level_Select; PinHeader_1x03_P2.54mm_Vertical
J4: Board supply; PinHeader_2x02_P2.54mm_Vertical
J6: I²C debug; PinHeader_1x02_P2.54mm_Vertical
J7: R bypass; PinSocket_1x02_P2.54mm_Vertical
J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23: Manual backup; PinHeader_1x03_P2.54mm_Vertical
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15, JP16: Bypass JP; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
L1: 4u7; Ind_5050
L2: 3u3; L_Taiyo-Yuden_NR-50xx_HandSoldering
Q1, Q2, Q3, Q4, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q14, Q15, Q16, Q17, Q18, Q20, Q22, Q23, Q24, Q25, Q26, Q27, Q28, Q31, Q32, Q33, Q34, Q35, Q36, Q37, Q38, Q39, Q40: 2N7002; SOT-23
Q5, Q13: NDS355AN; SOT-23
Q19, Q21, Q29, Q30: PJA3441; SOT-23
R1, R5, R11, R20, R43, R49, R55, R61, R67, R73, R79, R85, R91, R97, R103, R109, R115, R121, R127, R133, R144, R145, R150, R152, R154, R156, R158, R160, R166, R168, R170, R172, R174, R176, R178, R180, R182, R184, R185: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R6, R12, R16, R19, R22, R23, R24, R25, R26, R27, R28, R29, R47, R48, R53, R54, R59, R60, R65, R66, R71, R72, R77, R78, R83, R84, R89, R90, R95, R96, R101, R102, R107, R108, R113, R114, R119, R120, R125, R126, R131, R132, R142, R143: 270; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R7, R10, R13, R17, R18, R38, R39, R40: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R8, R14, R50, R51, R52, R56, R57, R58, R62, R63, R64, R68, R69, R70, R74, R75, R76, R80, R81, R82, R86, R87, R88, R92, R93, R94, R98, R99, R100, R104, R105, R106, R110, R111, R112, R116, R117, R118, R122, R123, R124, R128, R129, R130, R135, R136, R137, R146, R147, R148: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9, R21: 3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 620; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R30, R31, R32, R33, R34, R35, R36, R37: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R41, R42: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R44, R164: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R45: 43k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R46: 8k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R138: 820k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R139: 120k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R140: 75k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R141: 24k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R149, R151, R153, R155, R157, R159, R165, R167, R169, R171, R173, R175, R177, R179, R181, R183: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R161: 30k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R162, R163: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: MOV-07D220K; RV_Disc_D9mm_W3.5mm_P5mm
SW1: Button Manual; SW_PUSH_1P1T_6x3.5mm_H5.0_APEM_MJTP1250
SW2: Enable; SW_DIP_SPSTx01_Slide_9.78x4.72mm_W7.62mm_P2.54mm
TP1: TP_LEDC3; TestPoint_Pad_D2.0mm
TP2: TP_LEDC4; TestPoint_Pad_D2.0mm
TP3: TP_FUEL; TestPoint_Pad_D2.0mm
TP4: TP12VP; TestPoint_Pad_D2.0mm
TP5: TP5V; TestPoint_Pad_D2.0mm
TP6: TP3V3; TestPoint_Pad_D2.0mm
TP7: TPSDA; TestPoint_Pad_D2.0mm
TP8: TPSCL; TestPoint_Pad_D2.0mm
U1, U3: TCA9555PWR; TSSOP-24_4.4x7.8mm_P0.65mm
U2: ESP32-S3-DevKitC

Connections:
+3V3: C1.2, C2.2, R10.2, R16.1, R18.2, R20.1, R39.1, R40.2, R41.2, R42.2, R47.1, R53.1, R59.1, R65.1, R71.1, R77.1, R83.1, R89.1, R95.1, R101.1, R107.1, R113.1, R119.1, R125.1, R131.1, R142.1, SW1.1, U3.21 (A0)
+5V_1: J2.3, J3.3, J5.3, R15.1, R17.1, R38.1
/3V3_SMPS/3V3_EN: IC2.5 (EN), R138.2, R139.1
/3V3_SMPS/3V3_FB: C13.2, IC2.4 (FB), R140.2, R141.1
/3V3_SMPS/3V3_OUT: C13.1, C14.2, C15.1, C16.1, L2.2, R39.2, R140.1, TP6.1
/3V3_SMPS/3V3_SW: C12.1, IC2.2 (SW), L2.1
/5V_SMPS_1/5V_FB: C6.2, IC1.4 (FB), R45.2, R46.1
/5V_SMPS_1/5V_OUT: C6.1, C7.2, C8.1, C9.1, L1.2, R38.2, R45.1, TP5.1
/5V_SMPS_1/5V_SW: C5.1, IC1.2 (SW), L1.1
/5v_enable: R43.1, U2.12 (GPIO8/ADC1_CH7)
/POWER INPUT/Power_Fused: C17.2, F1.2, Q29.3 (D), RV1.2
/POWER INPUT/Power_Mid: D48.1 (K), Q29.2 (S), Q30.2 (S), R164.1
/POWER INPUT/Power_Pre-Filter: C19.2, FB1.1, Q30.3 (D)
/SCL: J6.1, R42.1, TP8.1, U1.22 (SCL), U2.6 (GPIO6/ADC1_CH5), U3.22 (SCL)
/SDA: J6.2, R41.1, TP7.1, U1.23 (SDA), U2.5 (GPIO5/ADC1_CH4), U3.23 (SDA)
/Switchable Resistor11/Res_GND: Q34.3 (D), R31.2
/Switchable Resistor11/Res_ON: R171.1, R172.1, U3.14 (P11)
/Switchable Resistor 0/Res_GND: Q23.3 (D), R22.2
/Switchable Resistor 0/Res_ON: R151.1, R152.1, U3.4 (P00)
/Switchable Resistor 1/Res_GND: Q22.3 (D), R23.2
/Switchable Resistor 1/Res_ON: R149.1, R150.1, U3.5 (P01)
/Switchable Resistor 2/Res_GND: Q24.3 (D), R24.2
/Switchable Resistor 2/Res_ON: R153.1, R154.1, U3.6 (P02)
/Switchable Resistor 3/Res_GND: Q25.3 (D), R25.2
/Switchable Resistor 3/Res_ON: R155.1, R156.1, U3.7 (P03)
/Switchable Resistor 4/Res_GND: Q26.3 (D), R26.2
/Switchable Resistor 4/Res_ON: R157.1, R158.1, U3.8 (P04)
/Switchable Resistor 5/Res_GND: Q27.3 (D), R27.2
/Switchable Resistor 5/Res_ON: R159.1, R160.1, U3.9 (P05)
/Switchable Resistor 6/Res_GND: Q31.3 (D), R28.2
/Switchable Resistor 6/Res_ON: R165.1, R166.1, U3.10 (P06)
/Switchable Resistor 7/Res_GND: Q32.3 (D), R29.2
/Switchable Resistor 7/Res_ON: R167.1, R168.1, U3.11 (P07)
/Switchable Resistor 10/Res_GND: Q33.3 (D), R30.2
/Switchable Resistor 10/Res_ON: R169.1, R170.1, U3.13 (P10)
/Switchable Resistor 12/Res_GND: Q35.3 (D), R32.2
/Switchable Resistor 12/Res_ON: R173.1, R174.1, U3.15 (P12)
/Switchable Resistor 13/Res_GND: Q36.3 (D), R33.2
/Switchable Resistor 13/Res_ON: R175.1, R176.1, U3.16 (P13)
/Switchable Resistor 14/Res_GND: Q39.3 (D), R34.2
/Switchable Resistor 14/Res_ON: R181.1, R182.1, U3.17 (P14)
/Switchable Resistor 15/Res_GND: Q38.3 (D), R35.2
/Switchable Resistor 15/Res_ON: R179.1, R180.1, U3.18 (P15)
/Switchable Resistor 16/Res_GND: Q40.3 (D), R36.2
/Switchable Resistor 16/Res_ON: R183.1, R184.1, U3.19 (P16)
/Switchable Resistor 17/Res_GND: Q37.3 (D), R37.2
/Switchable Resistor 17/Res_ON: R177.1, R178.1, U3.20 (P17)
/abs: D27.1 (K), R102.1, R103.1, U1.15 (P12)
/airbag: D19.1 (K), R78.1, R79.1, U1.7 (P03)
/alarm: D35.1 (K), R126.1, R127.1, U1.10 (P06)
/alternator: D11.1 (K), R54.1, R55.1, U1.18 (P15)
/backlight: D37.1 (K), R132.1, R133.1, U1.9 (P05)
/brakes: D13.1 (K), R60.1, R61.1, U1.4 (P00)
/button: D33.1 (K), R120.1, R121.1, SW1.2, U1.11 (P07)
/cel: D21.1 (K), R84.1, R85.1, U1.8 (P04)
/coolant: D31.1 (K), R114.1, R115.1, U1.13 (P10)
/door: D29.1 (K), R108.1, R109.1, U1.14 (P11)
/full_beams: D9.1 (K), R48.1, R49.1, U1.19 (P16)
/ign_EN: R19.1, SW2.1 (A), U2.41 (GPIO1/ADC1_CH0)
/ignition: D39.1 (K), R143.1, R144.1, U1.20 (P17)
/left_turn: D25.1 (K), R96.1, R97.1, U1.17 (P14)
/oil: D17.1 (K), R72.1, R73.1, U1.6 (P02)
/parking: D15.1 (K), R66.1, R67.1, U1.5 (P01)
/right_turn: D23.1 (K), R90.1, R91.1, U1.16 (P13)
/~ledc_chan_0: R11.1, R12.1, U2.18 (GPIO12/ADC2_CH1)
/~ledc_chan_1: R5.1, R6.1, U2.17 (GPIO11/ADC2_CH0)
/~ledc_chan_2: R1.1, R2.1, U2.16 (GPIO10/ADC1_CH9)
/~ledc_chan_3: TP1.1, U2.19 (GPIO13/ADC2_CH2)
/~ledc_chan_4: TP2.1, U2.20 (GPIO14/ADC2_CH3)
ABS_ActLO: J1.24, J17.2, JP10.2 (B)
AIRBAG_ActLO: J1.8, J13.2, JP6.2 (B)
ALARM_ActHI: J1.14, J21.2, JP14.2 (B)
ALTERN_ActLO: J1.19, J9.2, JP2.2 (B)
BATT12V+: F1.1, J1.1, J2.1, J3.1, J4.1, J4.3, J5.1, J8.3, J9.3, J10.3, J11.3, J12.3, J13.3, J14.3, J15.3, J16.3, J17.3, J18.3, J19.3, J20.3, J21.3, J22.3, J23.3, Q19.2 (S), Q21.2 (S), R9.1, R50.2, R51.2, R52.2, R56.2, R57.2, R58.2, R62.2, R63.2, R64.2, R68.2, R69.2, R70.2, R74.2, R75.2, R76.2, R80.2, R81.2, R82.2, R86.2, R87.2, R88.2, R92.2, R93.2, R94.2, R98.2, R99.2, R100.2, R104.2, R105.2, R106.2, R110.2, R111.2, R112.2, R116.2, R117.2, R118.2, R122.2, R123.2, R124.2, R128.2, R129.2, R130.2, R145.2, R185.2
BRAKE_ActLO: J1.2, J10.2, JP3.2 (B)
BTN_ActLO: J1.18, J20.2, JP13.2 (B)
CEL_ActLO: J1.10, J14.2, JP7.2 (B)
COOLANT_ActHI: J1.20, J19.2, JP12.2 (B)
DOOR_ActLO: J1.22, J18.2, JP11.2 (B)
FUEL_LVL_Rsense: J1.13, J7.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R34.1, R35.1, R36.1, R37.1, TP3.1
GND: C1.1, C2.1, C3.1, C4.1, C7.1, C8.2, C9.2, C10.1, C11.1, C14.1, C15.2, C16.2, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D10.1 (K), D12.1 (K), D14.1 (K), D16.1 (K), D18.1 (K), D20.1 (K), D22.1 (K), D24.1 (K), D26.1 (K), D28.1 (K), D30.1 (K), D32.1 (K), D34.1 (K), D36.1 (K), D38.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.2 (A), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), H1.1, H2.1, IC1.1 (GND), IC2.1 (GND), J1.3, J4.2, J4.4, J7.2, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, J17.1, J18.1, J19.1, J20.1, J21.1, J22.1, J23.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), Q11.2 (S), Q12.2 (S), Q13.2 (S), Q14.2 (S), Q15.2 (S), Q16.2 (S), Q17.2 (S), Q18.2 (S), Q20.2 (S), Q22.2 (S), Q23.2 (S), Q24.2 (S), Q25.2 (S), Q26.2 (S), Q27.2 (S), Q28.2 (S), Q31.2 (S), Q32.2 (S), Q33.2 (S), Q34.2 (S), Q35.2 (S), Q36.2 (S), Q37.2 (S), Q38.2 (S), Q39.2 (S), Q40.2 (S), R44.2, R46.2, R135.1, R136.1, R137.1, R139.2, R141.2, R146.1, R147.1, R148.1, R162.2, RV1.1, U1.2 (A1), U1.3 (A2), U1.12 (GND), U1.21 (A0), U2.22 (GND), U2.23 (GND), U2.24 (GND), U2.44 (GND), U3.2 (A1), U3.3 (A2), U3.12 (GND)
H_BEAM_ActHI: J1.17, J8.2, JP1.2 (B)
IGNITION_ActHI: J1.5, J23.2, JP16.2 (B), R161.1
L_BEAM_ActHI: J1.12, J22.2, JP15.2 (B)
L_TURN_ActHI: J1.21, J16.2, JP9.2 (B)
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), R9.2
unnamed: D4.2 (A), R12.2
unnamed: D5.2 (A), R15.2
unnamed: D6.2 (A), R16.2
unnamed: D7.2 (A), R19.2
unnamed: D8.2 (A), R21.2
unnamed: D9.2 (A), R47.2
unnamed: D10.2 (A), R48.2
unnamed: D11.2 (A), R53.2
unnamed: D12.2 (A), R54.2
unnamed: D13.2 (A), R59.2
unnamed: D14.2 (A), R60.2
unnamed: D15.2 (A), R65.2
unnamed: D16.2 (A), R66.2
unnamed: D17.2 (A), R71.2
unnamed: D18.2 (A), R72.2
unnamed: D19.2 (A), R77.2
unnamed: D20.2 (A), R78.2
unnamed: D21.2 (A), R83.2
unnamed: D22.2 (A), R84.2
unnamed: D23.2 (A), R89.2
unnamed: D24.2 (A), R90.2
unnamed: D25.2 (A), R95.2
unnamed: D26.2 (A), R96.2
unnamed: D27.2 (A), R101.2
unnamed: D28.2 (A), R102.2
unnamed: D29.2 (A), R107.2
unnamed: D30.2 (A), R108.2
unnamed: D31.2 (A), R113.2
unnamed: D32.2 (A), R114.2
unnamed: D33.2 (A), R119.2
unnamed: D34.2 (A), R120.2
unnamed: D35.2 (A), R125.2
unnamed: D36.2 (A), R126.2
unnamed: D37.2 (A), R131.2
unnamed: D38.2 (A), R132.2
unnamed: D39.2 (A), R142.2
unnamed: D40.2 (A), R143.2
unnamed: D41.2 (A), R149.2
unnamed: D42.2 (A), R151.2
unnamed: D43.2 (A), R153.2
unnamed: D44.2 (A), R155.2
unnamed: D45.2 (A), R157.2
unnamed: D46.2 (A), R159.2
unnamed: C18.2, D47.1 (K), Q28.1 (G), R161.2, R162.1
unnamed: D48.2 (A), Q29.1 (G), Q30.1 (G), R163.2, R164.2
unnamed: D49.2 (A), R165.2
unnamed: D50.2 (A), R167.2
unnamed: D51.2 (A), R169.2
unnamed: D52.2 (A), R171.2
unnamed: D53.2 (A), R173.2
unnamed: D54.2 (A), R175.2
unnamed: D55.2 (A), R177.2
unnamed: D56.2 (A), R179.2
unnamed: D57.2 (A), R181.2
unnamed: D58.2 (A), R183.2
unnamed: C5.2, IC1.6 (BST)
unnamed: IC1.5 (EN), R43.2, R44.1
unnamed: C12.2, IC2.6 (BST)
unnamed: J2.2, R3.2
unnamed: J3.2, R7.2
unnamed: J5.2, R13.2
unnamed: JP1.1 (A), Q4.3 (D), R50.1, R51.1, R52.1
unnamed: JP2.1 (A), Q5.3 (D), R56.1, R57.1, R58.1
unnamed: JP3.1 (A), Q6.3 (D), R62.1, R63.1, R64.1
unnamed: JP4.1 (A), Q7.3 (D), R68.1, R69.1, R70.1
unnamed: JP5.1 (A), Q8.3 (D), R74.1, R75.1, R76.1
unnamed: JP6.1 (A), Q9.3 (D), R80.1, R81.1, R82.1
unnamed: JP7.1 (A), Q10.3 (D), R86.1, R87.1, R88.1
unnamed: JP8.1 (A), Q11.3 (D), R92.1, R93.1, R94.1
unnamed: JP9.1 (A), Q12.3 (D), R98.1, R99.1, R100.1
unnamed: JP10.1 (A), Q13.3 (D), R104.1, R105.1, R106.1
unnamed: JP11.1 (A), Q14.3 (D), R110.1, R111.1, R112.1
unnamed: JP12.1 (A), Q15.3 (D), R116.1, R117.1, R118.1
unnamed: JP13.1 (A), Q16.3 (D), R122.1, R123.1, R124.1
unnamed: JP14.1 (A), Q17.3 (D), R128.1, R129.1, R130.1
unnamed: JP15.1 (A), Q19.3 (D), R135.2, R136.2, R137.2
unnamed: JP16.1 (A), Q21.3 (D), R146.2, R147.2, R148.2
unnamed: Q1.1 (G), R1.2
unnamed: Q2.1 (G), R5.2
unnamed: Q3.1 (G), R11.2
unnamed: Q4.1 (G), R49.2
unnamed: Q5.1 (G), R55.2
unnamed: Q6.1 (G), R61.2
unnamed: Q7.1 (G), R67.2
unnamed: Q8.1 (G), R73.2
unnamed: Q9.1 (G), R79.2
unnamed: Q10.1 (G), R85.2
unnamed: Q11.1 (G), R91.2
unnamed: Q12.1 (G), R97.2
unnamed: Q13.1 (G), R103.2
unnamed: Q14.1 (G), R109.2
unnamed: Q15.1 (G), R115.2
unnamed: Q16.1 (G), R121.2
unnamed: Q17.1 (G), R127.2
unnamed: Q18.3 (D), Q19.1 (G), R145.1
unnamed: Q18.1 (G), R133.2
unnamed: Q20.3 (D), Q21.1 (G), R185.1
unnamed: Q20.1 (G), R144.2
unnamed: Q22.1 (G), R150.2
unnamed: Q23.1 (G), R152.2
unnamed: Q24.1 (G), R154.2
unnamed: Q25.1 (G), R156.2
unnamed: Q26.1 (G), R158.2
unnamed: Q27.1 (G), R160.2
unnamed: Q28.3 (D), R163.1
unnamed: Q31.1 (G), R166.2
unnamed: Q32.1 (G), R168.2
unnamed: Q33.1 (G), R170.2
unnamed: Q34.1 (G), R172.2
unnamed: Q35.1 (G), R174.2
unnamed: Q36.1 (G), R176.2
unnamed: Q37.1 (G), R178.2
unnamed: Q38.1 (G), R180.2
unnamed: Q39.1 (G), R182.2
unnamed: Q40.1 (G), R184.2
unnamed: R3.1, R4.2
unnamed: R7.1, R8.2
unnamed: R13.1, R14.2
unnamed: R18.1, U2.1 (3V3), U2.2 (3V3)
unnamed: R20.2, SW2.2 (B)
unnamed: R10.1, U1.24 (VCC)
unnamed: R17.2, U2.21 (5V)
unnamed: R40.1, U3.24 (VCC)
OIL_ALRM_ActLO: J1.6, J12.2, JP5.2 (B)
PARK_ActLO: J1.4, J11.2, JP4.2 (B)
Protected_12V: C3.2, C4.2, C10.2, C11.2, C20.2, C21.2, C22.2, FB1.2, IC1.3 (VIN), IC2.3 (VIN), R21.1, R138.1, TP4.1
RPM_HALL: J1.7, Q2.3 (D), R8.1
R_TURN_ActLO: J1.23, J15.2, JP8.2 (B)
SPEED_HALL: J1.9, Q1.3 (D), R4.1
WATER_T_PWM: J1.11, Q3.3 (D), R14.1
