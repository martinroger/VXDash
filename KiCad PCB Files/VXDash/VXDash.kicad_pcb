File: KiCad PCB Files/VXDash/VXDash.kicad_pcb (KiCad board)
At the start: 2 copper layers, 115 x 95 mm, 370 parts, among them IC1 CD74HC4050M96, IC10 ATA6561, IC2 74HC4067BQ-Q100J, IC2 SP721ABG, IC3 AP62200, IC4 AP62200, IC4 MP2322GQH-Z, IC5 AD8542ARMZ-REEL, IC5 AS2333_OpAmp, IC6 AD8542ARMZ-REEL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

Commit message: PCB layout in progress
Changed some pin assignments to aid routing.
Parts:
- removed the C13 at (153.9, 75.9)
- removed the C16 at (199.0, 65.8)
- removed the C18 at (202.9, 52.1)
- removed the C19 at (192.0, 54.4)
- removed C2, C3, C4, C5, C6: 100n, Capacitor_SMD:C_0603_1608Metric
- removed the C20 at (199.6, 50.5)
- removed the C23 at (193.8, 54.3)
- removed the C25 at (127.1, 80.4)
- removed the C26 at (127.1, 83.4)
- removed the C31 at (140.5, 80.4)
- removed the C31 at (6.54, 98.1)
- removed the C36 at (200.7, 80.4)
- removed the C36 at (37.7, 50.5)
- removed the C44 at (141.7, 65.3)
- removed the C45 at (-20.5, 94.8)
- removed the C45 at (144.3, 65.3)
- removed the C46 at (146.8, 65.3)
- removed the C46 at (-20.5, 97.3)
- removed the C47 at (149.4, 65.3)
- removed the C47 at (-20.5, 99.8)
- removed the C48 at (151.9, 65.3)
- removed the C48 at (54.2, 79.3)
- removed C5, C6: 22uF 16V, Capacitor_SMD:C_0805_2012Metric
- removed C50, C51, C52: 0.1uF 50V, Capacitor_SMD:C_0603_1608Metric
- removed C51: 22p, Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
- removed C53, C54: 22u, Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
- removed C55: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- removed C56: 33n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- removed D12, D13, D14, D15, D16, D17, D18, D19: BAT54, Diode_SMD:D_SOD-123
- removed the D2 at (143.4, 88.1)
- removed the D2 at (57.9, 95.0)
- removed the D5 at (170.4, 88.1)
- removed the D6 at (32.6, 51.0)
- removed the D6 at (180.6, 88.1)
- removed the D7 at (32.6, 54.3)
- removed the D8 at (32.6, 57.7)
- removed the D9 at (153.6, 88.1)
- removed the D9 at (32.6, 61.0)
- removed the F1 at (119.5, 82.9)
- removed the IC2 at (152.1, 128.4)
- removed the IC2 at (119.5, 76.7)
- removed the IC5 at (148.6, 77.0)
- removed the IC5 at (39.2, 64.2)
- removed the IC6 at (39.2, 68.8)
- removed the IC6 at (162.1, 77.0)
- removed the IC7 at (-13.0, 108.4)
- removed the IC7 at (175.5, 77.0)
- removed IC8: AP62200, Package_TO_SOT_SMD:TSOT-23-6_HandSoldering
- removed the IC9 at (-13.0, 129.6)
- removed the J1 at (15.6, 95.9)
- removed the J1 at (170.1, 97.4)
- removed the J2 at (115.6, 55.3)
- removed the J2 at (18.0, 51.6)
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Connections:
- net /5V_SMPS_1/5V_en renamed /5V_SMPS/5V_EN
- net /immobilizer renamed /cel
- net Net-(D11-K) renamed /POWER INPUT/Power_Mid
- net Net-(IC3-FB) renamed /5V_SMPS/5V_FB
- net Net-(IC4-EN) renamed /3V3_SMPS/3V3_EN
- C1 pad 1: /rpm -> +3V3
- C10 pad 1: Net-(PS1-BST) -> GND
- C10 pad 2: /12V_to_5V_AP63200WU-7/5V_SW -> +3V3
- C11 pad 1: /12V_to_5V_AP63200WU-7/5V_FB -> GND
- C11 pad 2: /12V_to_5V_AP63200WU-7/5V_REG_OUT -> BOOT_IO0
- C12 pad 1: /12V_to_5V_AP63200WU-7/5V_REG_OUT -> Net-(C12-Pad1)
- C14 pad 2: CONV_5V+ -> Protected_12V
- C15 pad 1: GND -> /5V_SMPS/5V_SW
- C15 pad 2: Net-(IC7-+IN_A) -> Net-(IC2-BST)
- C16 pad 1: +5V_1 -> +5V
- C17 pad 1: PROTECTED_12V+ -> GND
- C17 pad 2: GND -> +5V
- C18 pad 1: +5V_1 -> +5V
- C19 pad 1: +5V_1 -> +5V
- C21 pad 1: Net-(IC4-BST) -> GND
- C21 pad 2: Net-(IC4-SW) -> Protected_12V
- C22 pad 1: Net-(IC4-FB) -> /3V3_SMPS/3V3_SW
- C22 pad 2: Net-(C19-Pad1) -> Net-(IC3-BST)
- C23 pad 2: Net-(IC4-FB) -> /3V3_SMPS/3V3_FB
- C24 pad 1: fuel_level -> GND
- C24 pad 2: GND -> +3V3
- C27 pad 2: AnalogV_2 -> +3V3
- C28 pad 2: AnalogV_2 -> /ANALOGUE/r_adc_1
- C29 pad 2: AnalogV_3 -> /ANALOGUE/Rsensing_Pair1/ADC_B
- C30 pad 1: GND -> +3V3
- C30 pad 2: AnalogV_3 -> GND
- C32 pad 1: GND -> +5V
- C32 pad 2: AnalogV_4 -> GND
- C35 pad 2: PROTECTED_12V+ -> Net-(U19-AIN1)
- C37 pad 2: /ANALOGUE/r_adc_1 -> Net-(D6-A1)
- C38 pad 2: /ANALOGUE/r_adc_2 -> /ANALOGUE/v_adc_1
- C40 pad 2: Net-(IC6-+IN_A) -> /ANALOGUE/v_adc_2
- C41 pad 1: GND -> +3V3
- C41 pad 2: Net-(IC5-+IN_A) -> GND
- C42 pad 1: GND -> +5V
- C42 pad 2: CONV_5V+ -> GND
- C43 pad 1: /ESP32/ADC_2 -> +5V
- C49 pad 1: sensor_R_2 -> GND
- C49 pad 2: GND -> Protected_12V
- C57 pad 2: /ANALOGUE/r_adc_6 -> /USBC/VCC_5V
- C60 pad 1: +5V_2 -> +5V
- C7 pad 1: /12V_to_5V_AP63200WU-7/5V_REG_OUT -> GND
- C7 pad 2: GND -> +3V3
- C8 pad 1: PROTECTED_12V+ -> GND
- C8 pad 2: GND -> +3V3
- C9 pad 1: PROTECTED_12V+ -> /esp32_enable
- D1 pad 1: Net-(D1-A1) -> FUEL_LVL_Rsense
- D1 pad 2: GND -> Net-(D1-A)
- D3 pad 1: AnalogR_3 -> /ANALOGUE/Rsensing_Pair1/Sender_B
- D4 pad 1: AnalogR_4 -> +3V3
- D4 pad 2: Net-(D4-A) -> /ANALOGUE/Rsensing_Pair1/ADC_B
- D6 pad 1: Net-(D4-A1) -> Net-(D6-A1)
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Routing:
- net REG_3.3V+: track 388.2 -> 0.00 mm, vias 4 -> 0
- net Protected_12V: track 0.00 -> 213.9 mm, vias 0 -> 12
- net PROTECTED_12V+: track 192.9 -> 0.00 mm, vias 9 -> 0
- net CONV_5V+: track 184.9 -> 0.00 mm, vias 5 -> 0
- net button: track 148.3 -> 0.00 mm, vias 1 -> 0
- net COM: track 134.9 -> 0.00 mm, vias 2 -> 0
- net right_turn: track 133.8 -> 0.00 mm, vias 3 -> 0
- net left_turn: track 131.8 -> 0.00 mm, vias 3 -> 0
- net S1: track 122.2 -> 0.00 mm, vias 2 -> 0
- net S3: track 120.4 -> 0.00 mm, vias 2 -> 0
- net S2: track 116.6 -> 0.00 mm, vias 2 -> 0
- net S0: track 104.7 -> 0.00 mm, vias 3 -> 0
- net rpm: track 65.8 -> 0.00 mm, vias 2 -> 0
- net water_T: track 65.6 -> 0.00 mm, vias 1 -> 0
- net speed: track 57.1 -> 0.00 mm, vias 2 -> 0
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- added copper zone on F.Cu, net +3V3
- added copper zone on F.Cu, net +5V
- added copper zone on F.Cu, net /3V3_SMPS/3V3_SW
- added copper zone on F.Cu, net /5V_SMPS/5V_SW
- added copper zone on F.Cu, net /POWER INPUT/Power_Fused
- added copper zone on F.Cu, net BATT12V+
- added copper zone on F.Cu, net Protected_12V
- removed copper zone on F.Cu, net /12V_to_5V_AP63200WU-7/5V_REG_OUT
- removed copper zone on F.Cu, net /12V_to_5V_AP63200WU-7/5V_SW
- removed copper zone on F.Cu, net /right_turn
- removed copper zone on B.Cu, net GND
- removed copper zone on F.Cu, net GND
- removed copper zone on F.Cu, net Net-(C19-Pad1)
- removed copper zone on F.Cu, net Net-(IC4-SW)
- removed copper zone on F.Cu, net PROTECTED_12V+
Other:
- copper layers 2 -> 4
- board text removed: "+5V"
- board text removed: "GND"
- board text removed: "RX"
- board text removed: "TX"

Commit message: Connectors packaging and additions to main board
- DXF file for connector packaging and NO go zones on main PCB (see PR #41 notes )
- Additional internal connectors for UART access to the display boards
- DNP capacitor on EN. Good idea ?
Other:
- board text added: "NO GO Connectors"

Commit message: ESP32S3 Reference footprint
- VXDash : updating footprint to Espressif's official one.
Parts:
- U2: footprint RF_Module:ESP32-S3-WROOM-1 -> VXDash_IC:ESP32-S3-WROOM-1
- moved U2 3.23 mm to (155.4, 56.2)

Commit message: New main dash PCB - WIP inc. CAD
Parts:
- removed MTH6: MountingHole_3.5mm_Pad_Via, MountingHole:MountingHole_3.5mm_Pad_Via
- added C2: 10u, Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder, B.Cu at (61.0, 77.8)
- added C3: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, B.Cu at (64.5, 79.0)
- added C4: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, B.Cu at (72.5, 81.5)
- added C5: 22p, Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder, B.Cu at (69.2, 75.8)
- added C50: 1u, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, B.Cu at (160.5, 37.0)
- added C51: 22u, Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder, B.Cu at (60.5, 82.0)
- added C52: 22u, Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder, B.Cu at (58.0, 82.0)
- added C6: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, B.Cu at (62.5, 81.3)
- added D12: BATT12V_ON, LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder, F.Cu at (199.0, 101.8)
- added D13: 5V_ON, LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder, F.Cu at (80.8, 92.5)
- added D14: 3V3_ON, LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder, B.Cu at (227.1, 71.2)
- added D15: EXP_INT_ON, LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder, F.Cu at (169.5, 50.2)
- added D16: RPM_PLS, LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder, F.Cu at (192.0, 53.8)
- added D17: SPD_PLS, LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder, F.Cu at (172.8, 54.0)
- added D18: WAT_PWM, LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder, F.Cu at (172.8, 60.2)
- added D19: 5V_AUX_ON, LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder, F.Cu at (60.5, 92.5)
- added D20: BAT54, Diode_SMD:D_SOD-123, F.Cu at (159.8, 98.2)
- added D21: BAT54, Diode_SMD:D_SOD-123, F.Cu at (151.2, 98.2)
- added J10: CANbus, VXDash_connectors:TE_DTF13-4P, F.Cu at (119.0, 114.0)
- added J8: LD_UART, Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical, B.Cu at (171.0, 38.9)
- added J9: RD_UART, Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical, B.Cu at (130.0, 53.6)
- added L3: 4u7, VXDash_inductors:Ind_5050, B.Cu at (67.5, 84.2)
- added R100: 620, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (80.8, 89.0)
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Connections:
- C10 pad 2: +3V3 -> /esp_3V3
- C37 pad 2: Net-(D6-A1) -> Net-(C37-Pad2)
- C39 pad 2: Net-(D7-A1) -> Net-(C39-Pad2)
- C42 pad 1: +5V -> /Right Display CAN XCVR/V_SUPPLY
- C43 pad 1: +5V -> /Right Display CAN XCVR/V_SUPPLY
- C8 pad 2: +3V3 -> /esp_3V3
- D6 pad 1: Net-(D6-A1) -> +3V3
- D6 pad 2: GND -> /ANALOGUE/v_adc_1
- D7 pad 1: Net-(D7-A1) -> +3V3
- D7 pad 2: GND -> /ANALOGUE/v_adc_2
- IC4 pad 5: (no net) -> Net-(IC4B-+)
- IC4 pad 6: (no net) -> /ANALOGUE/v_ref
- IC4 pad 7: (no net) -> Net-(IC4-Pad7)
- IC5 pad 1: Net-(IC5-Pad1) -> GND
- IC5 pad 2: /ANALOGUE/v_ref -> /5V_SMPS_AUX/5V_SW
- IC5 pad 3: Net-(IC5A-+) -> Protected_12V
- IC5 pad 4: unconnected-(IC5-Pad4) -> /5V_SMPS_AUX/5V_FB
- IC5 pad 5: (no net) -> Net-(IC5-EN)
- IC5 pad 6: (no net) -> Net-(IC5-BST)
- Q4 pad 2: Net-(IC5A-+) -> Net-(IC4B-+)
- R1 pad 1: +3V3 -> /esp_3V3
- R2 pad 1: Net-(U2-3V3) -> /esp_3V3
- R54 pad 1: Net-(IC5-Pad1) -> Net-(IC4-Pad7)
- R57 pad 1: Net-(IC5A-+) -> Net-(IC4B-+)
- R68 pad 2: Net-(D6-A1) -> Net-(C37-Pad2)
- R69 pad 1: Net-(D6-A1) -> Net-(C37-Pad2)
- R7 pad 1: /5V_SMPS/5V_EN -> /5V_enable
- R72 pad 2: Net-(D7-A1) -> Net-(C39-Pad2)
- R73 pad 1: Net-(D7-A1) -> Net-(C39-Pad2)
- R76 pad 2: +5V -> /Right Display CAN XCVR/V_SUPPLY
- U2 pad 10: unconnected-(U2-GPIO17/U1TXD/ADC2_CH6-Pad10) -> /LD_GP0
- U2 pad 11: unconnected-(U2-GPIO18/U1RXD/ADC2_CH7/CLK_OUT3-Pad11) -> /5V_enable
- U2 pad 15: unconnected-(U2-GPIO3/TOUCH3/ADC1_CH2-Pad15) -> /5V_aux_enable
- U2 pad 2: Net-(U2-3V3) -> /esp_3V3
- U2 pad 32: unconnected-(U2-MTCK/GPIO39/CLK_OUT3/SUBSPICS1-Pad32) -> /RD_GP0
- U2 pad 33: unconnected-(U2-MTDO/GPIO40/CLK_OUT2-Pad33) -> /RD_RXD
- U2 pad 34: unconnected-(U2-MTDI/GPIO41/CLK_OUT1-Pad34) -> /RD_TXD
- U2 pad 8: unconnected-(U2-GPIO15/U0RTS/ADC2_CH4/XTAL_32K_P-Pad8) -> /LD_RXD
- U2 pad 9: unconnected-(U2-GPIO16/U0CTS/ADC2_CH5/XTAL_32K_N-Pad9) -> /LD_TXD
Routing:
- net Protected_12V: track 213.9 -> 0.00 mm, vias 12 -> 0
- net FUEL_LVL_Rsense: track 61.4 -> 119.1 mm, vias 0 -> 1
- net /ignition: track 46.2 -> 2.49 mm
- net /abs: track 43.1 -> 2.49 mm
- net /brakes: track 40.2 -> 2.49 mm
- net /door: track 37.1 -> 2.49 mm
- net /parking: track 34.1 -> 2.49 mm
- net /right_turn: track 31.1 -> 2.49 mm
- net CAN_L: track 42.5 -> 13.9 mm, vias 1 -> 0
- net CAN_H: track 39.8 -> 13.9 mm, vias 1 -> 0
- net /oil: track 28.1 -> 2.49 mm
- net /coolant: track 25.1 -> 2.58 mm
- net Net-(IC4-Pad1): track 0.00 -> 21.8 mm, vias 0 -> 2
- net IGNITION_ActHI: track 64.4 -> 42.9 mm, vias 0 -> 2
- net +5V: track 20.8 -> 0.00 mm, vias 2 -> 0
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- added copper zone on B.Cu, net +3V3
- added copper zone on B.Cu, net +5V
- added copper zone on B.Cu, net +5V_AUX
- added copper zone on B.Cu, net /3V3_SMPS/3V3_SW
- added copper zone on B.Cu, net /5V_SMPS/5V_SW
- added copper zone on B.Cu, net /5V_SMPS_AUX/5V_SW
- added copper zone on B.Cu, net /POWER INPUT/Power_Fused
- added copper zone on B.Cu, net /POWER INPUT/Power_Mid
- added copper zone on B.Cu, net /POWER INPUT/Power_Pre-Filter
- added copper zone on B.Cu, net BATT12V+
- added copper zone on B.Cu, net Protected_12V
- removed copper zone on F.Cu, net +3V3
- removed copper zone on F.Cu, net +5V
- removed copper zone on F.Cu, net /3V3_SMPS/3V3_SW
- removed copper zone on F.Cu, net /5V_SMPS/5V_SW
- removed copper zone on F.Cu, net /POWER INPUT/Power_Fused
- removed copper zone on F.Cu, net /POWER INPUT/Power_Mid
- removed copper zone on F.Cu, net /POWER INPUT/Power_Pre-Filter
- removed copper zone on F.Cu, net BATT12V+
- removed copper zone on F.Cu, net Protected_12V
Other:
- board size 115 x 95 mm -> 245.2 x 136.8 mm
- board text removed: "NO GO Connectors"

Commit message: Connector BOM, reference outline
- JST connectors added to BOM, arbitrary connections (will probably need remapping)
- BOM should roughly be complete as is (at least footprints-wise)
- Reference DXF and PDF added for outlines and display positions
Other:
- board text added: "4mm OFFSET"
- board text added: "CLUSTER REAR OUTLINE"
- board text added: "CONNECTOR BOSS ZONE"
- board text added: "CONNECTORS EXTERNAL ZONE"
- board text added: "LEFT DISPLAY CONNECTOR"
- board text added: "NB : VIEW IS FROM BACK"
- board text added: "PROTECTED SPACE FOR M4 HEATSERT BOSS"
- board text added: "RIGHT DISPLAY CONNECTOR"
