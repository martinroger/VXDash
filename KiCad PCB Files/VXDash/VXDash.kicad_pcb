# Repository martinroger/VXDash (continued)

## KiCad design KiCad PCB Files/VXDash.kicad_pcb (continued)

Parts:
R6, R7: 1K; R_0805_2012Metric; Manufacturer_Part_Number RMCF0805FT1K00
U1: SFH617A-2X009T; SMDIP-4_W7.62mm; Manufacturer_Part_Number SFH617A-2X009T

Connections:
ALTERN_ActLO: U1.2; also elsewhere on the board
GND: U1.3; also elsewhere on the board
unnamed: R6.2, U1.1
PROTECTED_12V+: R6.1; also elsewhere on the board
REG_3.3V+: R7.2; also elsewhere on the board
alternator: R7.1, U1.4; also elsewhere on the board

Parts of its further copies:
R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R28, R31, R34, R46: 1K; R_0805_2012Metric; Manufacturer_Part_Number RMCF0805FT1K00
U2, U3, U4, U5, U6, U7, U8, U9, U10: SFH617A-2X009T; SMDIP-4_W7.62mm; Manufacturer_Part_Number SFH617A-2X009T

Connections of its further copies:
ABS_ActLO: U10.2; also elsewhere on the board
AIRBAG_ActLO: U5.2; also elsewhere on the board
AnalogV_4: R46.1; also elsewhere on the board
BCKLIGHT_ActHI: R34.1; also elsewhere on the board
BRAKE_ActLO: U2.2; also elsewhere on the board
BTN_ActLO: U7.2; also elsewhere on the board
COOLANT_ActLO: U8.2; also elsewhere on the board
DOOR_ActLO: U9.2; also elsewhere on the board
FBEAMS_ActHI: R28.1; also elsewhere on the board
GND: U2.3, U3.3, U4.3, U5.3, U6.3, U7.3, U8.3, U9.3, U10.3; also elsewhere on the board
IMMO_ActLO: U6.2; also elsewhere on the board
unnamed: R8.2, U2.1
unnamed: R10.2, U3.1
unnamed: R12.2, U4.1
unnamed: R14.2, U5.1
unnamed: R16.2, U6.1
unnamed: R18.2, U7.1
unnamed: R20.2, U8.1
unnamed: R22.2, U9.1
unnamed: R24.2, U10.1
unnamed 77: R28.2; also elsewhere on the board
unnamed 80: R34.2; also elsewhere on the board
OIL_ALRM_ActLO: U4.2; also elsewhere on the board
PARK_ActLO: U3.2; also elsewhere on the board
PROTECTED_12V+: R8.1, R10.1, R12.1, R14.1, R16.1, R18.1, R20.1, R22.1, R24.1; also elsewhere on the board
REG_3.3V+: R9.2, R11.2, R13.2, R15.2, R17.2, R19.2, R21.2, R23.2, R25.2, R31.2; also elsewhere on the board
abs: R25.1, U10.4; also elsewhere on the board
airbag: R15.1, U5.4; also elsewhere on the board
brakes: R9.1, U2.4; also elsewhere on the board
button: R19.1, U7.4; also elsewhere on the board
coolant: R21.1, U8.4; also elsewhere on the board
door: R23.1, U9.4; also elsewhere on the board
immobilizer: R17.1, U6.4; also elsewhere on the board
left_turn: R31.1; also elsewhere on the board
oil: R13.1, U4.4; also elsewhere on the board
parking: R11.1, U3.4; also elsewhere on the board
sensor_V_4: R46.2; also elsewhere on the board

Notes on the sheet:
SFH617A-2X009T CTR 63-125% Vf = 1.35V Circuit CTR: If = (12V-1.35V)/1K = 10.65mA Ic = 3.3/1K = 3.3mA CTRc = 3.3/10.65 = 30.9% Opto is always in saturation

Parts:
C17, C21, C23: 100nF 50V; C_0402_1005Metric; Manufacturer_Part_Number GRM155R61H104KE19D
C18, C19: 22uF 16V; C_0805_2012Metric; Manufacturer_Part_Number CL21A226MOCLRNC
C20: 2.2µF; C_0402_1005Metric; Manufacturer_Part_Number GRM155R60J225KE95D
C22: 22pF; C_0402_1005Metric; Manufacturer_Part_Number C0402C220J5GAC7411
IC4: MP2322GQH-Z; MP2322GQHZ; Manufacturer_Part_Number MP2322GQH-Z; Mouser Part Number 946-MP2322GQH-Z
L2: SRP3212A-3R3M; L_1210_3225Metric; Tolerance 20%; Manufacturer_Part_Number SRP3212A-3R3M
R37: 220K; R_0402_1005Metric; Manufacturer_Part_Number CRCW0402220KFKED
R38: 976K; R_0402_1005Metric; Manufacturer_Part_Number CRCW0402976KFKED
R39: 0R; R_0402_1005Metric; Manufacturer_Part_Number RC0402JR-070RL

Connections:
GND: C17.2, C18.2, C19.2, C20.2, C23.1, IC4.1 (GND), R37.1; also elsewhere on the board
unnamed: C19.1, C22.2, C23.2, L2.2, R38.2, R39.1
unnamed: C21.1, IC4.7 (BST)
unnamed: C22.1, IC4.5 (FB), R37.2, R38.1
unnamed: C21.2, IC4.8 (SW), L2.1
unnamed: C20.1, IC4.4 (VCC)
PROTECTED_12V+: C17.1, C18.1, IC4.2 (IN), IC4.3 (EN); also elsewhere on the board
REG_3.3V+: R39.2; also elsewhere on the board

Notes on the sheet:
Acting as a fuse of sorts ?

Parts:
C14, C40: 0.1uF 50V; C_0603_1608Metric; Manufacturer_Part_Number CL10B104KB8NNWC
D3, D4: PMEG3010EH; D_SOD-123F; Manufacturer_Part_Number PMEG3010EH,115
IC6: AD8542ARMZ-REEL; SOP65P490X110-8N; Manufacturer_Part_Number AD8542ARMZ-REEL; Mouser Part Number 584-AD8542ARMZ-R
Q3, Q4: DMG2301L; SOT-23; Manufacturer_Part_Number DMG2301L-7
R48: 6k8; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-076K8L
R51, R53: 27k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-0727KL
R54, R55: 51k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-0751KL
R57: 330k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-07330KL

Connections:
/Rsensing_Pair2/Rset_1: IC6.2 (-IN_A), Q3.2 (S); also elsewhere on the board
/Rsensing_Pair2/Rset_2: IC6.6 (-IN_B), Q4.2 (S); also elsewhere on the board
AnalogR_3: D3.1 (K); also elsewhere on the board
AnalogR_4: D4.1 (K); also elsewhere on the board
CONV_5V+: C14.2, IC6.8 (V+), R48.1; also elsewhere on the board
GND: C14.1, C40.1, IC6.4 (V-), R54.2, R55.2, R57.2; also elsewhere on the board
unnamed: D3.2 (A), Q3.3 (D), R51.1
unnamed: D4.2 (A), Q4.3 (D), R53.1
unnamed: C40.2, IC6.3 (+IN_A), IC6.5 (+IN_B), R48.2, R57.1
unnamed: IC6.1 (OUT_A), Q3.1 (G)
unnamed: IC6.7 (OUT_B), Q4.1 (G)
sensor_R_3: R51.2, R54.1; also elsewhere on the board
sensor_R_4: R53.2, R55.1; also elsewhere on the board

Parts of its further copies:
C13, C15, C41, C42: 0.1uF 50V; C_0603_1608Metric; Manufacturer_Part_Number CL10B104KB8NNWC
D2, D5, D6, D9: PMEG3010EH; D_SOD-123F; Manufacturer_Part_Number PMEG3010EH,115
IC5, IC7: AD8542ARMZ-REEL; SOP65P490X110-8N; Manufacturer_Part_Number AD8542ARMZ-REEL; Mouser Part Number 584-AD8542ARMZ-R
Q5, Q6, Q7, Q8: DMG2301L; SOT-23; Manufacturer_Part_Number DMG2301L-7
R56, R72: 6k8; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-076K8L
R58, R59: 330k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-07330KL
R61, R66, R73, R75: 27k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-0727KL
R67, R68, R74, R76: 51k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-0751KL

Connections of its further copies:
/Rsensing_Pair1/Rset_1: IC5.2 (-IN_A), Q7.2 (S); also elsewhere on the board
/Rsensing_Pair1/Rset_2: IC5.6 (-IN_B), Q8.2 (S); also elsewhere on the board
/Rsensing_Pair3/Rset_1: IC7.2 (-IN_A), Q5.2 (S); also elsewhere on the board
/Rsensing_Pair3/Rset_2: IC7.6 (-IN_B), Q6.2 (S); also elsewhere on the board
AnalogKR_1: D6.1 (K); also elsewhere on the board
AnalogR_1: D2.1 (K); also elsewhere on the board
AnalogR_2: D9.1 (K); also elsewhere on the board
CONV_5V+: C13.2, C42.2, IC5.8 (V+), IC7.8 (V+), R56.1, R72.1; also elsewhere on the board
FUEL_LVL_Rsense: D5.1 (K); also elsewhere on the board
GND: C13.1, C15.1, C41.1, C42.1, IC5.4 (V-), IC7.4 (V-), R58.2, R59.2, R67.2, R68.2, R74.2, R76.2; also elsewhere on the board
unnamed: D2.2 (A), Q7.3 (D), R73.1
unnamed: D5.2 (A), Q5.3 (D), R61.1
unnamed: D6.2 (A), Q6.3 (D), R66.1
unnamed: D9.2 (A), Q8.3 (D), R75.1
unnamed: C41.2, IC5.3 (+IN_A), IC5.5 (+IN_B), R58.1, R72.2
unnamed: IC5.1 (OUT_A), Q7.1 (G)
unnamed: IC5.7 (OUT_B), Q8.1 (G)
unnamed: C15.2, IC7.3 (+IN_A), IC7.5 (+IN_B), R56.2, R59.1
unnamed: IC7.1 (OUT_A), Q5.1 (G)
unnamed: IC7.7 (OUT_B), Q6.1 (G)
fuel_level: R61.2, R67.1; also elsewhere on the board
sensor_KR_1: R66.2, R68.1; also elsewhere on the board
sensor_R_1: R73.2, R74.1; also elsewhere on the board
sensor_R_2: R75.2, R76.1; also elsewhere on the board

Notes on the sheet:
Vref set to 4.9V As the divider follows the supply, its less susceptible to supply variation than a fixed voltage (zener). i.e. always close to 100mV across Iset resistor.
Full-scale 5V = just under 3V3 (~3.27V)
Current is set as follows : - 100mV across 22R = ~4.54mA. MOSFET used to avoid influence from additional base current. - For fuel level and common sensors (0-250Ohm), that gives a sensor voltage of anywhere between 0 and 1.135V - Practically the maximum voltage that can be is 4.9V-0.550V = 4.35V (t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
Ideas/issues : - How to account for variations in the Vf of PMEG3010EH Alex: At ~4.5mA, Vf varies by ~120mV from -40 to 80degC. This equates to ~24ohm error over a large temp Martin : gotcha - 5V may not be true 5V -> Zener regulator there too ? evaluate possible swings Alex: Used a Vref that follo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

Parts:
R26, R27: 1K; R_0805_2012Metric; Manufacturer_Part_Number RMCF0805FT1K00
U11: SFH617A-2X009T; SMDIP-4_W7.62mm; Manufacturer_Part_Number SFH617A-2X009T

Connections:
GND: U11.2, U11.3; also elsewhere on the board
IGNITION_ActHI: R26.1; also elsewhere on the board
unnamed: R26.2, U11.1
REG_3.3V+: R27.2; also elsewhere on the board
ignition: R27.1, U11.4; also elsewhere on the board

Parts of its further copies:
R10, R25, R28, R29, R30, R31, R32, R33, R34, R35, R46: 1K; R_0805_2012Metric; Manufacturer_Part_Number RMCF0805FT1K00
U12, U13, U14, U15: SFH617A-2X009T; SMDIP-4_W7.62mm; Manufacturer_Part_Number SFH617A-2X009T

Connections of its further copies:
AnalogV_4: R46.1; also elsewhere on the board
BCKLIGHT_ActHI: R34.1; also elsewhere on the board
FBEAMS_ActHI: R28.1; also elsewhere on the board
GND: U12.2, U12.3, U13.2, U13.3, U14.2, U14.3, U15.2, U15.3; also elsewhere on the board
L_TURN_ActHI: R30.1; also elsewhere on the board
unnamed 68: R10.2; also elsewhere on the board
unnamed: R28.2, U12.1
unnamed: R30.2, U13.1
unnamed: R32.2, U14.1
unnamed: R34.2, U15.1
PROTECTED_12V+: R10.1; also elsewhere on the board
REG_3.3V+: R25.2, R29.2, R31.2, R33.2, R35.2; also elsewhere on the board
R_TURN_ActHI: R32.1; also elsewhere on the board
abs: R25.1; also elsewhere on the board
backlight: R35.1, U15.4; also elsewhere on the board
full_beams: R29.1, U12.4; also elsewhere on the board
left_turn: R31.1, U13.4; also elsewhere on the board
right_turn: R33.1, U14.4; also elsewhere on the board
sensor_V_4: R46.2; also elsewhere on the board

Notes on the sheet:
SFH617A-2X009T CTR 63-125% Vf = 1.35V Circuit CTR: If = (12V-1.35V)/1K = 10.65mA Ic = 3.3/1K = 3.3mA CTRc = 3.3/10.65 = 30.9% Opto is always in saturation

Parts:
C24, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52: 0.1uF 50V; C_0603_1608Metric; Manufacturer_Part_Number CL10B104KB8NNWC
U16: ESP32-DevKitC

Connections:
/ESP32/ADC_2: C43.1, U16.4 (SENSOR_VN/GPIO39/ADC1_CH3)
/ESP32/RX1: U16.27 (GPIO16); also elsewhere on the board
/ESP32/TX1: U16.28 (GPIO17); also elsewhere on the board
COM: U16.33 (GPIO21); also elsewhere on the board
GND: C24.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, U16.14 (GND), U16.32 (GND), U16.38 (GND); also elsewhere on the board
REG_3.3V+: U16.1 (3V3); also elsewhere on the board
S0: U16.13 (MTDI/GPIO12/ADC2_CH5); also elsewhere on the board
S1: U16.25 (GPIO0/BOOT/ADC2_CH1); also elsewhere on the board
S2: U16.24 (ADC2_CH2/GPIO2); also elsewhere on the board
S3: U16.23 (MTDO/GPIO15/ADC2_CH3); also elsewhere on the board
button: U16.31 (GPIO19); also elsewhere on the board
fuel_level: C24.1, U16.3 (SENSOR_VP/GPIO36/ADC1_CH0); also elsewhere on the board
left_turn: U16.26 (ADC2_CH0/GPIO4); also elsewhere on the board
right_turn: U16.29 (GPIO5); also elsewhere on the board
rpm: U16.37 (GPIO23); also elsewhere on the board
sensor_KR_1: C52.1, U16.15 (MTCK/GPIO13/ADC2_CH4); also elsewhere on the board
sensor_R_1: C48.1, U16.9 (DAC_1/ADC2_CH8/GPIO25); also elsewhere on the board
sensor_R_2: C49.1, U16.10 (DAC_2/ADC2_CH9/GPIO26); also elsewhere on the board
sensor_R_3: C50.1, U16.11 (ADC2_CH7/GPIO27); also elsewhere on the board
sensor_R_4: C51.1, U16.12 (MTMS/GPIO14/ADC2_CH6); also elsewhere on the board
sensor_V_1: C44.1, U16.5 (VDET_1/GPIO34/ADC1_CH6); also elsewhere on the board
sensor_V_2: C45.1, U16.6 (VDET_2/GPIO35/ADC1_CH7); also elsewhere on the board
sensor_V_3: C46.1, U16.7 (32K_XP/GPIO32/ADC1_CH4); also elsewhere on the board
sensor_V_4: C47.1, U16.8 (32K_XN/GPIO33/ADC1_CH5); also elsewhere on the board
speed: U16.36 (GPIO22); also elsewhere on the board
water_T: U16.30 (GPIO18); also elsewhere on the board

Parts:
C33, C34, C35, C37: 0.1uF 50V; C_0603_1608Metric; Manufacturer_Part_Number CL10B104KB8NNWC
C36: 1uF; C_0603_1608Metric; Voltage 25V; Tolerance 10%; Manufacturer_Part_Number UMK107BJ105KA-T
D1, D10: 18V; D_SOD-123; Manufacturer_Part_Number BZT52C18-TP
F2: 0ZRB0250FF1E; Fuse_BelFuse_0ZRE0033FF_L11.4mm_W3.8mm; Manufacturer_Part_Number 0ZRB0250FF1E
FB1: 120R@100MHz; L_0805_2012Metric; Manufacturer_Part_Number 742792023
Q1: 2N7002; SOT-23; Manufacturer_Part_Number 2N7002-TP
Q2: PJA3441; SOT-23; Manufacturer_Part_Number PJA3441_R1_00001
R62, R64: 1K; R_0805_2012Metric; Manufacturer_Part_Number RMCF0805FT1K00
R63, R65: 100K; R_0402_1005Metric; Manufacturer_Part_Number CRCW0402100KFKEDC
RV1: MOV-07D220K; RV_Disc_D9mm_W3.5mm_P5mm; Manufacturer_Part_Number MOV-07D220K

Connections:
/Power_Input/Power_Fused: C33.2, D10.1 (K), F2.2, Q2.2 (S), R65.1, RV1.2
/Power_Input/Power_Pre-Filter: C37.2, FB1.1, Q2.3 (D)
BATT12V+: F2.1; also elsewhere on the board
GND: C33.1, C34.1, C35.1, C36.2, C37.1, D1.2 (A), Q1.2 (S), R63.2, RV1.1; also elsewhere on the board
IGNITION_ActHI: R62.1; also elsewhere on the board
unnamed: C34.2, D1.1 (K), Q1.1 (G), R62.2, R63.1
unnamed: D10.2 (A), Q2.1 (G), R64.2, R65.2
unnamed: Q1.3 (D), R64.1
PROTECTED_12V+: C35.2, C36.1, FB1.2; also elsewhere on the board

Parts of its further copies:
R10, R25, R28, R31, R34, R46: 1K; R_0805_2012Metric; Manufacturer_Part_Number RMCF0805FT1K00

Connections of its further copies:
AnalogV_4: R46.1; also elsewhere on the board
BCKLIGHT_ActHI: R34.1; also elsewhere on the board
FBEAMS_ActHI: R28.1; also elsewhere on the board
unnamed 68: R10.2; also elsewhere on the board
unnamed 77: R28.2; also elsewhere on the board
unnamed 80: R34.2; also elsewhere on the board
PROTECTED_12V+: R10.1; also elsewhere on the board
REG_3.3V+: R25.2, R31.2; also elsewhere on the board
abs: R25.1; also elsewhere on the board
left_turn: R31.1; also elsewhere on the board
sensor_V_4: R46.2; also elsewhere on the board

Notes on the sheet:
TODO: Look at load disconnect options if needed?
PJA3441 40V Vds max 3.1A max Vgs-th 2.5V max 88mOhm max +-20V Vgs max Also provides reverse protection
Voltage spike protection. Automotive 12V supply can see spikes >60V due to load-dump, etc. Varistor 18V max working, 24V max clamping 250A.
0ZRB0250FF1E 2.5A Hold max 5A trip 10.3s time-to-trip

Schematic: 12V_to_5V_AP63200WU-7.kicad_sch, 12V to 5V conversion

Parts:
C5, C6, C7, C8, C12: 22uF 16V; C_0805_2012Metric; Manufacturer_Part_Number CL21A226MOCLRNC
C9, C10, C16: 100nF 50V; C_0402_1005Metric; Manufacturer_Part_Number GRM155R61H104KE19D
C11: 100pF; C_0402_1005Metric; Manufacturer_Part_Number CC0402JRNPO9BN101
L1: 10uH; L_Bourns-SRN6028; Manufacturer_Part_Number BWVS00606045100M00
PS1: AP63200WU-7; SOT95P280X100-6N; Manufacturer_Part_Number AP63200WU-7; Mouser Part Number 621-AP63200WU-7
R1: 51k; R_0402_1005Metric; Manufacturer_Part_Number RC0402FR-0751KL
R2: 470k; R_0402_1005Metric; Manufacturer_Part_Number RC0402FR-07470KL
R3: 82k; R_0402_1005Metric; Manufacturer_Part_Number CRGCQ0402F82K
R4: 430k; R_0402_1005Metric; Manufacturer_Part_Number RC0402FR-07430KL
R5: 0R; R_0402_1005Metric; Manufacturer_Part_Number RC0402JR-070RL

Connections:
/12V_to_5V_AP63200WU-7/5V_EN: PS1.2 (EN), R1.2, R2.2
/12V_to_5V_AP63200WU-7/5V_FB: C11.1, PS1.1 (FB), R3.1, R4.1
/12V_to_5V_AP63200WU-7/5V_REG_OUT: C5.1, C7.1, C11.2, C12.1, C16.1, L1.2, R4.2, R5.1
/12V_to_5V_AP63200WU-7/5V_SW: C10.2, L1.1, PS1.5 (SW)
CONV_5V+: R5.2; also elsewhere on the board
GND: C5.2, C6.2, C7.2, C8.2, C9.2, C12.2, C16.2, PS1.4 (GND), R1.1, R3.2; also elsewhere on the board
unnamed: C10.1, PS1.6 (BST)
PROTECTED_12V+: C6.1, C8.1, C9.1, PS1.3 (VIN), R2.1; also elsewhere on the board

Notes on the sheet:
R2 = (0.932 x (Von - Voff)) / 4.1uA. If we have Von - Voff as ~2V hysteresis R2 = (0.932 x 2) / 0.0000041 = ~454k. Closest value = 470k gives around 2.06V R1 = (1.1 x R2) / (Voff - 1.1V +5.5uA x R2) If we have Voff ~9V R1 = (1.1 x 470k) / (9 - 1.1 = 0.0000055 x 470k) = 49.308k. Closest value = 51k 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
All resistors low tolerance All capacitors low ESR
Rule of thumb. Inductor current rating roughly 1.35 x maximum current output. Calculated as load current + ripple current (I_load + (I_pk-pk /2))
MAX 2A CONTINUOUS OUTPUT
Feedback divider R4 = R3 x ((5 / 0.8) -1)

Board: 2 copper layers, 115.0 x 95.0 mm, 180 parts (1 on the bottom side), 121 nets.

Other parts of the board:
MTH1, MTH2, MTH3, MTH4, MTH5, MTH6: MountingHole_3.5mm_Pad_Via
R43: 2K; R_0805_2012Metric

Their connections:
GND: MTH1.1, MTH2.1, MTH3.1, MTH4.1, MTH5.1, MTH6.1, R43.1; also elsewhere on the board
sensor_V_2: R43.2; also elsewhere on the board

## Code that names these connections

File Code/VXDash/VXDash.ino (part):

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const int S1        = 0;
const int S2        = 2;
const int S3        = 15;
const int COM       = 21;
const int ADC_1     = 36;
const int ADC_2     = 39; //Can be used later to sense 12V level, circuitry missing
const int ADC_3     = 34;
const int ADC_4     = 35;
const int ADC_5     = 32;
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const int ADC_9     = 27;
const int ADC_10    = 14;
const int ADC_11    = 13;
const int Counter_1 = 23; //RPM
const int Counter_2 = 22; //SPEED
const int Counter_3 = 18;  //Water temp, was 4
const int Digital_1 = 19;
const int Digital_2 = 4;
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Timer<millis> fastRefresh = 100;

// p_ variables are meant for limiting refresh attempts
uint16_t speed = 0;                       //Last calculated value
uint16_t p_speed = 0;                     //Previous refresh value
uint16_t speed_raw = 0;                   //Last raw value (PPS)
uint16_t p_speed_raw = 0;                 //Previous raw value (PPS)
volatile uint16_t speedPulseCounter = 0;  //Counter of pulses
SMA<10,uint16_t,uint16_t> speedPulseSMA = {0};

uint16_t rpm = 0;
uint16_t p_rpm = 0;
uint16_t rpm_raw = 0;
uint16_t p_rpm_raw = 0;
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uint8_t fuelLevel = 0;
uint16_t fuel_raw = 0;

uint8_t coolant = 0;
uint16_t coolant_raw = 0;
volatile uint32_t coolant_tmstp = 0;           //Microseconds
volatile uint16_t coolant_deltaTime = 1000;    //Microseconds
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  pinMode(S1,OUTPUT);
  pinMode(S2,OUTPUT);
  pinMode(S3,OUTPUT);
  pinMode(COM,INPUT);

  pinMode(Counter_1,INPUT_PULLDOWN);
  attachInterrupt(digitalPinToInterrupt(Counter_1),rpmPulse,RISING);
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
## Commit log (part)

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2023-04-07 Base commit
2023-04-07 Pre-PCB layout commit
    Footprints and special parts not included in Kicad project
    No PCB layout
    Netclasses not set up
    No code
2023-04-07 Backlink to CADLAB.io has been added.
2023-04-07 WIP commit
2023-04-10 Added Schematic PDF export
2023-04-10 v1.0
    - First PCB layout publication
    - Titled schematics
    - Added Revisions to Schematics and PCB
    - iBOM release
    - PDF export of PCB design
2023-04-14 Submodule kicad_libs
2023-04-14 Re-submodules
2023-04-16 Added thermal reliefs to GND
2023-04-16 Added more Thermal reliefs to the relays and varistor
2023-04-21 Added power input sch
    Added power input sheet.
    Relays removed.
    MOSFETs added for switching power.
2023-04-22 Update VXDash.kicad_sch
    Update TODO frame
2023-04-22 PCB adaptation
    - Updated footprints
    - Started grouping
    - Hid a few references
2023-04-22 1.1HW and Schematics -> PR
    - Updated all dates in title blocks
    - Added both FET based new power supply and protection circuits - completely winged the zones
    - Completed PCB layout, passes DRCs --> Needs review
    - Updated PCB metadata
    - Relocated 5th mounting hole a bit
    - Regenerated interactive BOM
2023-04-22 B06 renamed to BCKLIGHT
2023-04-24 Replaced input capacitors before PS1
2023-04-24 Updated 5V switching reg circuit
    - Changed input and output capacitors.
    - Modified EN and FB resistor values to match datasheet calculations.
    - Changed inductor to higher current rated part.
2023-04-24 PCB updates for power input and 5V regulator
    Updated footprints and PCB layout for new power input and modified 5V switching regulator.
2023-04-24 Consolidated merges
2023-04-30 Added first draft of Op-amp based circuitry
    Also some rationalisation of the components to avoid near-duplicates (e.g. 0.1uF 50V caps)
2023-04-30 Added PDF schematic for reference
2023-05-07 HMIStressTest INO start
2023-05-07 Initial stress testing program running
    A lot of segmentation on long progress bars doing fast sweeps (like RPM for example
    No value-repetition check on maths that are being sent over
    Monospaced fonts are a must
2023-05-12 Set up the backdrop for the main app
2023-05-14 Minor corrections
    Some mistqkes in INO
    Added the touch debug flag
2023-05-14 PCB layout update 1.2.1
    Updated with OpAmp circuitry plus some component identification
2023-05-16 Squashed commit of the following:
    commit 5d265e0e6d749114a68b27b45df218b106b0dda5
    Author: Martin <martin.roger@me.com>
    Date: Sun May 14 20:34:43 2023 +0200
    PCB layout update 1.2.1
    Updated with OpAmp circuitry plus some component identification
    commit e510fc9f0677414791fc51d243bf00155fb26728
2023-05-16 Added simulation files
    LTspice simulation files for reference
2023-05-20 Comments
    @Alex-XNR
    Just confirmed with comments to educate me.
    I think the only point that remains open is the question of Rf and Ri ? I can't remember where I saw they were included and I can't see, to find anymore.
    For the higher resistance I/O I think I will try with a higher Iset resistor ? With my crappy simulator it seems to run.
2023-05-20 Externalised the Iset resistor
2023-05-20 Mid PCB layout
2023-05-21 Pre release benchboard
2023-05-23 Updated 12V to 3V3
    Simplified 12V to 3V3 switcher
2023-05-23 Updated opamp footprint
2023-05-23 GND fill thermal reliefs
    Changed the GND plane fill to thermal relief to aid manufacture
2023-05-27 Reverted GND plane thermal reliefs
    Everyone gets thermal reliefs... you get thermal reliefs, YOU GET THERMAL RELIEFS !
2023-05-27 Adaptations and GND stitching
2023-05-28 Update NanoVXPulsator.ino
    Works somewhat accurately
2023-06-18 v1.2.3
    - Removed one 270R resistor otherwise the pots serve no purpose
    - Added some silkscreen references
    - Regenerated PDFs
2023-06-18 SW Corrections
    Corrected inverted logic for tell tales
    Corrected KR1 attribution
    Added fuel level alarm below 10%
2023-06-18 Minor changes, ADC correction
    - R4 ADC pin was not correctly set
    - logic on the overheat lamp
2023-07-01 Update VXDash.ino
    Introduction of raw values with correct type, sent to screen.
2023-07-09 Update VXDash.ino
    Introducing timers
2023-09-03 Update VXDash.ino
    Added implementation for RPM, tried to stabilise with pulldowns but it doesn't really change anything
2023-09-03 Added Simple Moving Average filters
    Surely more elegant things can be done.
    Will branch from here to make a pulse_count version
2023-09-04 GPIO39 relocated to GPIO4
    No BOM update
2024-04-27 Updated schematic and code
    GPIO4 is reenabled but subject to suspicions
    Schematic is updated, PCB is not.
2024-04-28 Code refactor for PlatformIO
    Refactoring and changes of order of declarations
2024-04-29 PCB update
    To reflect pin reassignments
2024-04-30 Updated LTSpice OpAmp circuit simulation
    Went and plonked a non-ideal LM358 OpAmp model. Suspicion is that the Common mode voltage is too close so it is non-linear above 80Ohm (which corroborates the observations from before.
    Suggestions of correction :
    - Change OPAMP with tighter common mode voltage limit
    - Change supply voltage of OPAMP to 7V and above -> Risky business
    - Change Rset and Vref to something lower. Ideally could go down to Vref at 3V and would lose a little bit of resolution between 3V and V3 but could also lose the voltage divider (5.1K and 2.7K) thus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
    In any case upload a V2 of the circuit with those different options
2024-04-30 Added simulations for OpAmp circuitry
2024-10-05 Replaced resistors and OpAmp
2024-10-05 Versioning and bom
2024-10-06 Using calibratred AnalogReadMilliVolts
2024-10-06 1.3.1 Decoupling capacitors on the ADC inputs
2024-10-06 Updated schematics and PCB layout for release board
2024-10-06 Thermal reliefs on ground plane
2024-10-06 Experimental UI setup
2024-10-08 Adding trip and odometer memory setting
2025-03-09 Restarting project + trinity
2025-03-10 Continuing migration
2025-03-11 Reconnections
2025-03-11 Update PCB to V9
2025-07-15 Simulations for adjustable analog sensor Rset
2025-07-20 Repo clean up
2025-07-20 WIP
    Main schematic re-layout.
    Updated 12V power input circuit.
    SMPS regulators changed.
    Updated analogue voltage circuit.
2025-08-05 Schematic pre-review
    WIP - final TODOs needed before review
2025-08-08 Library updates
2025-08-09 Minor updates
    - Coolant LOW actually tests as an Active Hi
    - ReadME file nuked
    - Minor updates
2025-08-09 SymLink to the LIB folder
    Adding a symbolic link to the Lib folder like such :
    ${VXDASH_LIB}/footprints/VXDash_inductors.pretty
2025-08-09 Minor changes
    - Connection for the caliber selection on the sensing circuit
    - Typo
2025-08-10 More changes (Primarily Remote ECU)
    - Emulator board project to a functional skeleton
    - Connectors board with ignition routing on CAN pin 4 to have switched signal available in the harness.
    - Remote ECU : added 12V reduced protection circuit (to be reviewed)
    - Remote ECU : Removed integrated CAN termination (should be on harness)
    - Remote ECU : added CAN passthrough
    - Remote ECU : added MCPWM channels
2025-08-10 Emulator board refinements
    - Is there stupid with the Active Hi Optos so that the logic is not inverted ?
    - Added N-Mosfet activatable resistors. Stupidly simple ? Better MOSFET recommendation ?
2025-08-14 Connectors packaging and additions to main board
    - DXF file for connector packaging and NO go zones on main PCB (see PR #41 notes )
    - Additional internal connectors for UART access to the display boards
    - DNP capacitor on EN. Good idea ?
2025-08-14 ESP32S3 Reference footprint
    - VXDash : updating footprint to Espressif's official one.
2025-08-14 Emulator : ERC and footprints
    Also moving some 0402 capacitors to 0603...
2025-08-19 Emulator : resistance banks layout
2025-08-19 Additional TP for Emulator board
2025-08-19 Emulator board : layout update
    - Moved to Open Drain style Mosfets instead of Optoisolators
    - Added manual push button for BUTTON
    - Did groups in the PCB layout
2025-08-20 Emulator board basic routing done
2025-08-20 Emulator board : DRC pass, review
2025-08-29 Emulator : layout and stitching
2025-08-31 Emulator : LCSC part numbers and production files
2025-09-01 Schematic update
2025-09-01 39Pin connector schematic added
2025-09-01 Preliminary schematic
2025-09-02 BOM updates
2025-09-02 BOM and Pre-routing
2025-09-02 DP routing sucks
2025-09-14 Schematic cleanliness update
2025-09-17 Struggles with extended routing
2025-09-18 Moving to single 39P
2025-09-19 Emulator : net naming convention consistency
2025-09-24 Added smaller DT connector to connector board
2025-10-01 Mini CAD reference files
2025-10-11 Sink resistors sizing, standard sink hier. sheet
    - Sink resistors resized for observed currents
    - Added hierarchical sheet for standard 17mA @ 13V sink
2025-10-13 Large schematic update
    - Fascia pass-through connector
    - Load emulators for all but turn signals
    - Test points
    - Additional caps for decoupling
    - Regrouped display connectors in single unit
    - Added CAN debug connector
2025-10-14 Added TLs load emulator
    50mA and sinking into one another
2025-10-14 Fields updates
2025-10-14 BOM first pass
    - Still missing some internal connectors definitions
    - Alternative to use a 4x4ch opto config instead of 16x1 ?
    - Alternative LiteOn optos identified (easier to source on LCSC)
2025-10-15 PCB refresh from schematic
2025-10-16 Pre-grouping phase 1
2025-10-16 Pre-grouping phase 2
    It's tight yo
2025-10-20 Form-fitting PCB outline
2025-10-25 Finer placement
2025-10-26 Primary layout done
    - No ground stitching or pours
    - Board edges to revise
    - DRC to check
    - BOM exclusions to check
2025-10-27 Simulation update
2025-10-27 Corrected OpAmp routing + more sims
2025-10-28 More sims !
2025-10-28 New PCB outline
    - Corrected small issues with solder expansion mask
    - Ground pour in place but no ground stitching
    - No Silkscreen texts
2025-10-28 Teardrops (literally)
    - Edge stitching necessary
    - Some rerouting necessary
2025-10-29 Second layout bulk
    Needs a cold-headed review
2025-11-05 Minor updates
2025-11-05 First batch order (JLC)
2025-11-05 Sanity check LTSpice simulation added
2025-11-06 Alternative OpAmp
2025-12-03 First build partial update
2026-01-08 Add CERN Open Hardware Licence Version 2
    Added CERN Open Hardware Licence Version 2 - Strongly Reciprocal to the project.
2026-01-08 Images added to the readme
2026-01-08 Image updates without origin dots
2026-01-12 Minor PR updates
    - Updated revision number in schematic
    - Minor change of track layout to avoid ground island
    - DRC OK and ERC OK
    - Removed stale notes from schematic
    - Updated PCB silkscreen
2026-01-20 Started work on RemoteECU schematic
2026-01-25 Gitignore updates
2026-01-25 Manual Mini Build BOM
2026-01-25 Internal harness schematic added for quotation
2026-02-10 Generating HTML bom correctly
2026-02-11 LCSC alt update
2026-03-04 Integrating DNP from Mini Build
2026-03-05 Pre-layout done
2026-03-06 OPT AIN3 as ref, filter caps adjusted
