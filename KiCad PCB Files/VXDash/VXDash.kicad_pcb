# Repository martinroger/VXDash (continued)

## KiCad design KiCad PCB Files/VXDash_RemoteECU/VXDash_RemoteECU.kicad_pcb (continued)

Schematic: AnalogV_Divider.kicad_sch, VXDash RemoteECU

Parts:
C24: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V
C25: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V
D3: BAV199; SOT-23-3
R43: 10R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R44: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
/AnaV_1: R43.1; also elsewhere on the board
/Analogue/v_adc_1: C25.2, R44.2; also elsewhere on the board
GND: C24.1, C25.1, D3.1 (A); also elsewhere on the board

Parts of its further copies:
C26, C31, C33: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V
C27, C32, C34: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V
D4, D5, D6: BAV199; SOT-23-3
R45, R49, R51: 10R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R46, R50, R52: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections of its further copies:
/AnaV_2: R45.1; also elsewhere on the board
/AnaV_3: R49.1; also elsewhere on the board
/AnaV_4: R51.1; also elsewhere on the board
/Analogue/v_adc_2: C27.2, R46.2; also elsewhere on the board
/Analogue/v_adc_3: C32.2, R50.2; also elsewhere on the board
/Analogue/v_adc_4: C34.2, R52.2; also elsewhere on the board
GND: C26.1, C27.1, C31.1, C32.1, C33.1, C34.1, D4.1 (A), D5.1 (A), D6.1 (A); also elsewhere on the board
unnamed: C26.2, D4.3 (K), R45.2, R46.1
unnamed: C31.2, D5.3 (K), R49.2, R50.1
unnamed: C33.2, D6.3 (K), R51.2, R52.1

Notes on the sheet:
Clamp diodes
Place near ADC ~16kHz RC

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
Board: 4 copper layers, 110.5 x 108.5 mm, 181 parts (146 on the bottom side), 143 nets.

Other parts of the board:
C39, C40: 33n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder

Their connections:
/Analogue/r_adc_3: C39.2; also elsewhere on the board
/Analogue/r_adc_4: C40.2; also elsewhere on the board
GND: C39.1, C40.1; also elsewhere on the board

## KiCad design KiCad PCB Files/ESP32P4_display_adapter_board/ESP32P4_display_adapter_board.kicad_pcb

Parts:
C1: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V
C2: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 25V
J1: Sel_VCC; PinHeader_1x03_P2.54mm_Vertical
J2: MIPI DSI; TE_1-1734248-5
J3: CTP_39
J4: S1; PinSocket_2x13_P2.54mm_Vertical
J5: S2; PinSocket_2x13_P2.54mm_Vertical
J6: 39Pin FPC; Hirose_FH26-39S-0.3SHW_2Rows-39Pins-1MP_P0.60mm_Horizontal
J7: WS_30P_rev; Hirose_FH12-30S-0.5SH_1x30-1MP_P0.50mm_Horizontal; not fitted
J8: WS_30P; Hirose_FH12-30S-0.5SH_1x30-1MP_P0.50mm_Horizontal; not fitted
J9: TP passthru; PinHeader_1x07_P2.54mm_Vertical
JP1: SDA_P-UP; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP2: SCL_P-UP; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R1, R2: 4k7; R_0603_1608Metric; not fitted

Connections:
+3.3V: C1.1, C2.1, J1.1, J2.14, J2.14_1 (14__1), J2.15, J2.15_1 (15__1), J3.1, J3.2, J4.1, J4.17, J5.5, J6.13, J6.14, J7.4, J7.5, J7.29, J7.30, J8.1, J8.2, J8.26, J8.27, J9.6, R1.1, R2.1; also elsewhere on the board
+5V: J1.3, J4.2, J4.4, J5.1, J9.7; also elsewhere on the board
/39-40Pin Bias Controller/Vin: J1.2; also elsewhere on the board
/BIAS_EN: J5.11; also elsewhere on the board
/BL_CTRL: J5.9; also elsewhere on the board
/DSI_CLK_N: J2.5, J2.5_1 (5__1), J6.30, J7.17, J8.14
/DSI_CLK_P: J2.6, J2.6_1 (6__1), J6.28, J7.16, J8.15
/DSI_D0_N: J2.8, J2.8_1 (8__1), J6.38, J7.11, J8.20
/DSI_D0_P: J2.9, J2.9_1 (9__1), J6.36, J7.10, J8.21
/DSI_D1_N: J2.2, J2.2_1 (2__1), J6.34, J7.14, J8.17
/DSI_D1_P: J2.3, J2.3_1 (3__1), J6.32, J7.13, J8.18
/LEDA: J6.2, J6.3, J7.1, J8.30; also elsewhere on the board
/LEDK: J6.4, J6.5, J7.2, J7.3, J8.28, J8.29; also elsewhere on the board
/MIPI_D2N: J6.26, J7.20, J8.11
/MIPI_D2P: J6.24, J7.19, J8.12
/PWM: J5.12, J7.8, J8.23
/RESET: J5.15, J6.16, J7.6, J8.25
/SCL: J2.11, J2.11_1 (11__1), J3.3, J4.5, J7.27, J8.4, J9.5, JP2.2 (B)
/SDA: J2.12, J2.12_1 (12__1), J3.4, J4.3, J7.26, J8.5, J9.4, JP1.2 (B)
/TE: J5.13, J6.18, J7.7, J8.24
/TP_INT: J3.7, J4.7, J7.25, J8.6, J9.3
/TP_RESET: J3.10, J4.11, J7.28, J8.3, J9.2
/VDD(+5V): J6.10, J6.11; also elsewhere on the board
/VDD(-5V): J6.7, J6.8; also elsewhere on the board
GND: C1.2, C2.2, J2.1, J2.1_1 (1__1), J2.4, J2.4_1 (4__1), J2.7, J2.7_1 (7__1), J2.10, J2.10_1 (10__1), J2.13, J2.13_1 (13__1), J3.5, J3.6, J4.6, J4.9, J4.14, J4.20, J4.25, J5.3, J5.4, J5.7, J5.10, J5.18, J5.25, J5.26, J6.1, J6.6, J6.9, J6.12, J6.15, J6.17, J6.19, J6.23, J6.27, J6.31, J6.35, J6.39, J6.MP (MountPin), J7.9, J7.12, J7.15, J7.18, J7.21, J7.24, J7.MP (MountPin), J8.7, J8.10, J8.13, J8.16, J8.19, J8.22, J8.MP (MountPin), J9.1; also elsewhere on the board
unnamed: J7.22, J8.9
unnamed: J7.23, J8.8
unnamed: JP1.1 (A), R1.2
unnamed: JP2.1 (A), R2.2

Notes on the sheet:
Bias double PSU alternative - TPS65100-Q1 - TPS6513x
Backlight PSU alternative - TPS61165

Parts:
C3: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V
C4, C6: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 25V
C5, C7: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V
D1: 1N5819HW-7-F; D_SOD-123
L1: 15uH; L_Taiyo-Yuden_NR-60xx_HandSoldering
R3: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 30k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R7: 10; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 3k3; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: AP3032KTR-G1; SOT-23-6

Connections:
+3.3V: R9.1; also elsewhere on the board
+5V: C4.1, L1.2, U1.6 (VIN); also elsewhere on the board
/BL_CTRL: R3.1; also elsewhere on the board
/LEDA: C6.1, C7.1, D1.1, R8.2; also elsewhere on the board
/LEDK: R5.1, R6.2, R7.1; also elsewhere on the board
GND: C3.2, C4.2, C5.2, C6.2, C7.2, R5.2, R7.2, U1.2 (GND); also elsewhere on the board
unnamed: C3.1, R3.2, R4.1
unnamed: C5.1, R9.2, U1.4 (CTRL)
unnamed: R4.2, R6.1, U1.3 (FB)
unnamed: R8.1, U1.5 (OV)
unnamed: D1.2, L1.1, U1.1 (SW)

Notes on the sheet:
Assuming 0 leakage current in R5 Vref = 200mV Rsense = 5Ohm Iled = 40mA

Parts:
C8, C10, C11: 10uF; C_0805_2012Metric; Voltage 10V
C9: 100nF; C_0805_2012Metric; Voltage 25V
L2, L3: 4.7uH; L_1008_2520Metric
U2: TPS65133DPDR; WSON-12-1EP_3x3mm_P0.5mm_EP1.5x2.5mm_ThermalVias

Connections:
/39-40Pin Bias Controller/Vin: C8.1, C9.1, L2.2, U2.11 (AVIN), U2.12 (PVIN); also elsewhere on the board
/BIAS_EN: U2.7 (EN); also elsewhere on the board
/VDD(+5V): C11.1, U2.3 (VPOS); also elsewhere on the board
/VDD(-5V): C10.1, U2.9 (VNEG); also elsewhere on the board
GND: C8.2, C9.2, C10.2, C11.2, L3.1, U2.2 (PGND), U2.4 (GND), U2.5 (AGND), U2.6 (GND), U2.8 (GND), U2.13 (EPAD); also elsewhere on the board
unnamed: L3.2, U2.10 (SWN)
unnamed: L2.1, U2.1 (SWP)

Board: 2 copper layers, 50.0 x 74.0 mm, 34 parts (2 on the bottom side), 31 nets.

## KiCad design KiCad PCB Files/VXDash.kicad_pcb

Parts:
C1, C2, C3, C4, C38, C39: 0.1uF 50V; C_0603_1608Metric; Manufacturer_Part_Number CL10B104KB8NNWC
F1: Polyfuse; Fuse_1210_3225Metric
IC1: CD74HC4050M96; SOIC127P600X175-16N; Manufacturer_Part_Number CD74HC4050M96; Mouser Part Number 595-CD74HC4050M96
IC2: SP721ABG; SOIC127P600X175-8N; Manufacturer_Part_Number SP721ABG; Mouser Part Number 576-SP721ABG
IC3: 74HC4067BQ-Q100J; 74HC4067BQQ100J; Manufacturer_Part_Number 74HC4067BQ-Q100J; Mouser Part Number 771-74HC4067BQ-Q100J
J1: MX34036UF2; Manufacturer_Part_Number MX34036UF2; Mouser Part Number 656-MX34036UF2
J2: Conn_01x04_Socket; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal
R49, R50, R52, R60, R69: 22R; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-0722RL
R70: 51R; R_0603_1608Metric; Manufacturer_Part_Number RMCF0603FT51R0

Connections:
5V_SENSOR: F1.2, J1.36
/ESP32/RX1: J2.3; also elsewhere on the board
/ESP32/TX1: J2.2; also elsewhere on the board
/Rsensing_Pair1/Rset_1: R49.2; also elsewhere on the board
/Rsensing_Pair1/Rset_2: R50.1; also elsewhere on the board
/Rsensing_Pair2/Rset_1: R52.2; also elsewhere on the board
/Rsensing_Pair2/Rset_2: R60.1; also elsewhere on the board
/Rsensing_Pair3/Rset_1: R69.2; also elsewhere on the board
/Rsensing_Pair3/Rset_2: R70.1; also elsewhere on the board
ABS_ActLO: J1.16; also elsewhere on the board
AIRBAG_ActLO: J1.11; also elsewhere on the board
ALTERN_ActLO: J1.7; also elsewhere on the board
AnalogKR_1: J1.25; also elsewhere on the board
AnalogR_1: J1.30; also elsewhere on the board
AnalogR_2: J1.29; also elsewhere on the board
AnalogR_3: J1.28; also elsewhere on the board
AnalogR_4: J1.27; also elsewhere on the board
AnalogV_1: IC2.1 (IN_1), J1.35; also elsewhere on the board
AnalogV_2: IC2.2 (IN_2), J1.34; also elsewhere on the board
AnalogV_3: IC2.3 (IN_3), J1.33; also elsewhere on the board
AnalogV_4: IC2.5 (IN_4), J1.32; also elsewhere on the board
BATT12V+: J1.1; also elsewhere on the board
BCKLIGHT_ActHI: J1.3; also elsewhere on the board
BRAKE_ActLO: J1.8; also elsewhere on the board
BTN_ActLO: J1.13; also elsewhere on the board
COM: IC3.1 (Z); also elsewhere on the board
CONV_5V+: F1.1, IC2.8 (V+), J2.4, R49.1, R50.2, R52.1, R60.2, R69.1, R70.2; also elsewhere on the board
COOLANT_ActLO: J1.14; also elsewhere on the board
DOOR_ActLO: J1.15; also elsewhere on the board
FBEAMS_ActHI: J1.4; also elsewhere on the board
FUEL_LVL_Rsense: J1.26; also elsewhere on the board
GND: C1.2, C2.1, C3.2, C4.2, C38.2, C39.2, IC1.5 (2A), IC1.7 (3A), IC1.8 (GND), IC1.11 (5A), IC2.4 (V-), IC3.12 (GND), IC3.15 (~E), J1.19, J1.24, J2.1; also elsewhere on the board
IGNITION_ActHI: J1.2; also elsewhere on the board
IMMO_ActLO: J1.12; also elsewhere on the board
L_TURN_ActHI: J1.5; also elsewhere on the board
OIL_ALRM_ActLO: J1.10; also elsewhere on the board
PARK_ActLO: J1.9; also elsewhere on the board
REG_3.3V+: IC1.1 (VCC), IC3.24 (VCC_1); also elsewhere on the board
RPM_HALL: C2.2, IC1.3 (1A), J1.17
R_TURN_ActHI: J1.6; also elsewhere on the board
S0: IC3.10 (S0); also elsewhere on the board
S1: IC3.11 (S1); also elsewhere on the board
S2: IC3.14 (S2); also elsewhere on the board
S3: IC3.13 (S3); also elsewhere on the board
SPEED_HALL: C4.1, IC1.14 (6A), J1.18
WATER_T_Rsense: C39.1, IC1.9 (4A), J1.31
abs: IC3.8 (Y1); also elsewhere on the board
airbag: IC3.3 (Y6); also elsewhere on the board
alternator: IC3.21 (Y10); also elsewhere on the board
backlight: IC3.17 (Y14); also elsewhere on the board
brakes: IC3.22 (Y9); also elsewhere on the board
button: IC3.5 (Y4); also elsewhere on the board
coolant: IC3.6 (Y3); also elsewhere on the board
door: IC3.7 (Y2); also elsewhere on the board
full_beams: IC3.18 (Y13); also elsewhere on the board
ignition: IC3.16 (Y15); also elsewhere on the board
immobilizer: IC3.4 (Y5); also elsewhere on the board
left_turn: IC3.19 (Y12); also elsewhere on the board
oil: IC3.2 (Y7); also elsewhere on the board
parking: IC3.23 (Y8); also elsewhere on the board
right_turn: IC3.20 (Y11); also elsewhere on the board
rpm: C1.1, IC1.2 (1Y); also elsewhere on the board
speed: C3.1, IC1.15 (6Y); also elsewhere on the board
water_T: C38.1, IC1.10 (4Y); also elsewhere on the board

Notes on the sheet:
50mA max consumption
3.3mA per segment 50mA total
Allocated 100mA, may be more like 50mA DO NOT TURN ON WIFI/RF
TODO Check current consumptions XXXmA total
Nextion Up to 500mA
2A Continuous output max
1A Continuous output
TODO and TOCHECK: - F1 polyfuse selection - Automated text placement on silkscreen - Current allocation table - https://github.com/martinroger/kicad_libs for custom symbols and footprints

Parts:
C25, C26: 0.1uF 50V; C_0603_1608Metric; Manufacturer_Part_Number CL10B104KB8NNWC
R40: 1K; R_0805_2012Metric; Manufacturer_Part_Number RMCF0805FT1K00
R41: 2K; R_0805_2012Metric; Manufacturer_Part_Number RMCF0805FT2K00

Connections:
AnalogV_1: C25.2, C26.2, R40.1; also elsewhere on the board
GND: C25.1, C26.1, R41.1; also elsewhere on the board
sensor_V_1: R40.2, R41.2; also elsewhere on the board

Parts of its further copies:
C27, C28, C29, C30, C31, C32: 0.1uF 50V; C_0603_1608Metric; Manufacturer_Part_Number CL10B104KB8NNWC
R10, R25, R28, R31, R34, R42, R44, R46: 1K; R_0805_2012Metric; Manufacturer_Part_Number RMCF0805FT1K00
R45, R47: 2K; R_0805_2012Metric; Manufacturer_Part_Number RMCF0805FT2K00

Connections of its further copies:
AnalogV_2: C27.2, C28.2, R42.1; also elsewhere on the board
AnalogV_3: C29.2, C30.2, R44.1; also elsewhere on the board
AnalogV_4: C31.2, C32.2, R46.1; also elsewhere on the board
BCKLIGHT_ActHI: R34.1; also elsewhere on the board
FBEAMS_ActHI: R28.1; also elsewhere on the board
GND: C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, R45.1, R47.1; also elsewhere on the board
unnamed 68: R10.2; also elsewhere on the board
unnamed 77: R28.2; also elsewhere on the board
unnamed 80: R34.2; also elsewhere on the board
PROTECTED_12V+: R10.1; also elsewhere on the board
REG_3.3V+: R25.2, R31.2; also elsewhere on the board
abs: R25.1; also elsewhere on the board
left_turn: R31.1; also elsewhere on the board
sensor_V_2: R42.2; also elsewhere on the board
sensor_V_3: R44.2, R45.2; also elsewhere on the board
sensor_V_4: R46.2, R47.2; also elsewhere on the board
