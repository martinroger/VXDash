# Repository martinroger/VXDash

File readme.md:

# VX Dash

## What is it ?
VX-Dash, also known as the "Binocle", is an effort to provide a restomodded instrument cluster to the Vauxhall VX220 and Opel Speedster, with additional customisable capabilities such as shift lights, dual mode brightness levels and extra sensors support.

This hardware is published under a [strongly reciprocal CERN license](LICENSE.md), meaning that while it can be reused for commercial projects, sources have to remain open, modifications have to be explicitely documented, and no warranty or liability is provided.

.png)

The objectives are to make this as economical as possible, and future-proofed, in order to avoid rare components or unreasonable price. To meet such objectives, modularity is key, as well as using popular development platforms, such as the excellent ESP32-S3.

## How good is it ?

The Binocle has the following features : 

- Displays all the information (telltales, RPM, Speed, Coolant temperature, Fuel Level) as the original cluster.
- Battery voltage is also now displayed
- Automatic night/day mode, each with adjustable brightness for comfortable driving
- User-adjustable visual alerts for over-temperature, and low fuel situations
- On-the-fly selectable MPH or KPH
- Discreet RPM alert with customisable threshold...
- ... or total blinkfest with two customisable thresholds for the track addicts
- CAN-based extendability to include other controller data, such as extra sensors
- Interchangeable fascia with publised CAN database, allowing end users to DIY their own displays
- Original design language perpetuated in the "binocle" fascia
- Settings screen accesible via simple touch swipes
- Fast boot-up time (approx 5 seconds)
- Special "factory" modes for all the controllers (Interface board, Display boards) to adjust critical calibration values such as odometer, trip, or fuel level compensation factors
- Also in the "factory" mode, webpage-based OTA update capabilities, with rollback protection and image validation for all controllers
- And again also in "factory" mode on the main board, CAN-based OTA update of the displays with just a few clicks !

## Can it be extended ?

Yes, and generally speaking only the Displays' SW needs to be adjusted for new sources of data over CAN, by adding extra gauges.

We are also working on designing a specific extension board, that can sit like an ECU in the back of the car and connect to popular extra sensors.

## Where is the software ?

The original software is currently maintained for all the boards in a [separate repository](https://github.com/martinroger/vx-binocle-espidf).

## Is it homologated for road use ?

Generally, NO !

## Other questions ?

[Check the wiki or open a discussion!](https://github.com/martinroger/VXDash/wiki)

## KiCad design KiCad PCB Files/VXDash/VXDash.kicad_pcb

Parts:
C1, C7, C9, C10: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C16194176
C8: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 10V; LCSC C19702
C12: 4n7; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C106218
C50: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 16V; LCSC C59782
D13: 5V_ON; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C157740; not fitted
D14: 3V3_ON; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C157740; not fitted
D19: 5V_AUX_ON; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C157740; not fitted
D20, D21, D31, D32: BAT54; D_SOD-123; LCSC C152458
H1: MH_top_right; MountingHole_3.5mm_Pad_Via; not fitted
H3: MH_mid_left; MountingHole_3.5mm_Pad_Via; not fitted
H4: MH_mid_right; MountingHole_3.5mm_Pad_Via; not fitted
H5: MH_bottom_left; MountingHole_3.5mm_Pad_Via; not fitted
H6: MH_bottom_right; MountingHole_3.5mm_Pad_Via; not fitted
H7: MH_center; MountingHole_3.5mm_Pad_Via; not fitted
J1: Header_VX220_RightAngle; Aptiv 12092886; LCSC N/A
J2: BenchPower; PinHeader_1x04_P2.54mm_Horizontal; not fitted
J5: CAN debug; PinHeader_1x03_P2.54mm_Vertical; LCSC C2937625; not fitted
J10: CANbus; TE_DTF13-4P; LCSC C7470975
J11: LD connector; JST_PH_S8B-PH-K_1x08_P2.00mm_Horizontal; LCSC C157915
J12: RD connector; JST_PH_S8B-PH-K_1x08_P2.00mm_Horizontal; LCSC C157915
JP1: CAN_H Term EN; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP2: CAN_L Term EN; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R1, R91, R130, R138, R139, R142: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C98220
R2, R90, R129: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17477
R3, R4: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C99782
R5, R6, R136, R137: 120R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C114245
R89, R100: 620R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C137695; not fitted
R92, R132, R134: 100R; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder; LCSC C309610
R93, R133, R135: 150R; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder; LCSC C877742
R97, R131: 15R; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; LCSC C137386
R101: 270R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C137754; not fitted
SW1: RESET; SW_PUSH_1P1T_6x3.5mm_H5.0_APEM_MJTP1250; LCSC C500068
SW2: BOOT; SW_PUSH_1P1T_6x3.5mm_H5.0_APEM_MJTP1250; LCSC C500068
TP1: 5V; TestPoint_Pad_D1.5mm
TP2: VBUS; TestPoint_Pad_D1.5mm
TP3: EXP_INT; TestPoint_Pad_D1.5mm
TP4: PROT_12V; TestPoint_Pad_D1.5mm
TP5: 5V_A; TestPoint_Pad_D1.5mm
TP6: 5V_B; TestPoint_Pad_D1.5mm
TP7: 3V3; TestPoint_Pad_D1.5mm
TP11: SCL; TestPoint_Pad_D1.5mm
TP12: SDA; TestPoint_Pad_D1.5mm
TP13: TX0; TestPoint_Pad_D1.5mm
TP14: RX0; TestPoint_Pad_D1.5mm
TP16: GND; TestPoint_Pad_D1.5mm
U1: TCA9555PWR; TSSOP-24_4.4x7.8mm_P0.65mm; LCSC C42420608
U2: ESP32-S3-WROOM-1; LCSC C2913202
U21: FM24CL16B; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C31082

Connections:
+3V3: C1.2, C7.2, R2.2, R3.2, R4.2, R101.1, R142.1, TP7.1, U1.24 (VCC), U21.8 (VDD); also elsewhere on the board
+5V: J12.1, R90.1, R100.1, TP5.1; also elsewhere on the board
+5V_AUX: J11.1, R89.1, R129.1, TP6.1; also elsewhere on the board
/5V_aux_enable: R130.1, U2.24 (GPIO47/SPICLK_P/SUBSPICLK_P_DIFF); also elsewhere on the board
/5V_enable: R91.2, U2.25 (GPIO48/SPICLK_N/SUBSPICLK_N_DIFF); also elsewhere on the board
/CAN_rx: U2.31 (GPIO38/FSPIWP/SUBSPIWP); also elsewhere on the board
/CAN_tx: U2.32 (MTCK/GPIO39/CLK_OUT3/SUBSPICS1); also elsewhere on the board
/LD_ALIVE: J11.5, R138.2, U2.20 (GPIO12/TOUCH12/ADC2_CH1/FSPICLK/FSPIIO6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)
/LD_CAN_rx: J11.3; also elsewhere on the board
/LD_CAN_tx: J11.2; also elsewhere on the board
/LD_GP0: J11.8, U2.23 (GPIO21)
/LD_RXD: J11.7, U2.22 (GPIO14/TOUCH14/ADC2_CH3/FSPIWP/FSPIDQS/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)
/LD_TXD: J11.6, U2.21 (GPIO13/TOUCH13/ADC2_CH2/FSPIQ/FSPIIO7/S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)
/Left Display CAN XCVR/V_SUPPLY: R129.2; also elsewhere on the board
/RD_ALIVE: J12.5, R139.1, U2.38 (GPIO2/TOUCH2/ADC1_CH1)
/RD_CAN_rx: J12.3; also elsewhere on the board
/RD_CAN_tx: J12.2; also elsewhere on the board
/RD_GP0: J12.8, U2.33 (MTDO/GPIO40/CLK_OUT2)
/RD_RXD: J12.7, U2.34 (MTDI/GPIO41/CLK_OUT1)
/RD_TXD: J12.6, U2.35 (MTMS/GPIO42)
/Right Display CAN XCVR/V_SUPPLY: R90.2; also elsewhere on the board
/SCL: R4.1, TP11.1, U1.22 (SCL), U2.17 (GPIO9/TOUCH9/ADC1_CH8/FSPIHD/SUBSPIHD), U21.6 (SCL); also elsewhere on the board
/SDA: R3.1, TP12.1, U1.23 (SDA), U2.15 (GPIO3/TOUCH3/ADC1_CH2), U21.5 (SDA); also elsewhere on the board
/SPARE_A8: J1.A8 (?)
/SPARE_B8: J1.B8 (?)
/Set_Hi_Chan_A: U2.8 (GPIO15/U0RTS/ADC2_CH4/XTAL_32K_P); also elsewhere on the board
/USBC/VBUS: TP2.1; also elsewhere on the board
/USBC/VCC_5V: TP1.1; also elsewhere on the board
/USB_DN: U2.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-); also elsewhere on the board
/USB_DP: U2.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+); also elsewhere on the board
/abs: U1.20 (P17); also elsewhere on the board
/airbag: U1.8 (P04); also elsewhere on the board
/alarm: U1.11 (P07); also elsewhere on the board
/alternator: U1.15 (P12); also elsewhere on the board
/backlight: U1.10 (P06); also elsewhere on the board
/brakes: U1.4 (P00); also elsewhere on the board
/button: U1.14 (P11), U2.18 (GPIO10/TOUCH10/ADC1_CH9/FSPICS0/FSPIIO4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); also elsewhere on the board
/cel: U1.9 (P05); also elsewhere on the board
/coolant: U1.16 (P13); also elsewhere on the board
/door: U1.18 (P15); also elsewhere on the board
/esp32_enable: C9.1, C50.2, R1.2, SW1.1, U2.3 (EN)
/esp_3V3: C8.2, C10.2, R1.1, R2.1, U2.2 (3V3)
/expander_INT: TP3.1, U1.1 (~INT), U2.7 (GPIO7/TOUCH7/ADC1_CH6)
/full_beams: U1.13 (P10), U2.19 (GPIO11/TOUCH11/ADC2_CH0/FSPID/FSPIIO5/S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); also elsewhere on the board
/ignition: U1.6 (P02); also elsewhere on the board
/left_turn: U1.17 (P14); also elsewhere on the board
/oil: U1.7 (P03); also elsewhere on the board
/parking: U1.5 (P01); also elsewhere on the board
/right_turn: U1.19 (P16); also elsewhere on the board
/rpm: U2.4 (GPIO4/TOUCH4/ADC1_CH3); also elsewhere on the board
/speed: U2.5 (GPIO5/TOUCH5/ADC1_CH4); also elsewhere on the board
/uart0_rx: TP14.1, U2.36 (U0RXD/GPIO44/CLK_OUT2)
/uart0_tx: TP13.1, U2.37 (U0TXD/GPIO43/CLK_OUT1)
/water_T: U2.6 (GPIO6/TOUCH6/ADC1_CH5); also elsewhere on the board
ABS_ActLO: J1.B12 (ABS), R131.2; also elsewhere on the board
AIRBAG_ActLO: J1.B4 (Airbag); also elsewhere on the board
ALARM_ActHI: J1.B7 (Alarm); also elsewhere on the board
ALTERN_ActLO: J1.A10 (Alternator), R92.2; also elsewhere on the board
BATT12V+: J1.A1 (12V), J2.1, J2.2; also elsewhere on the board
BOOT_IO0: R142.2, SW2.1, U2.27 (GPIO0/BOOT)
BRAKE_ActLO: J1.B1 (Brake_Fluid); also elsewhere on the board
BTN_ActLO: J1.B9 (Dash_Button); also elsewhere on the board
CAN_H: J5.2, J10.3, JP1.2 (B); also elsewhere on the board
CAN_L: J5.1, J10.2, JP2.2 (B); also elsewhere on the board
CEL_ActLO: J1.B5 (Immobiliser); also elsewhere on the board
COOLANT_ActHI: J1.B10 (Coolant_Level); also elsewhere on the board
DOOR_ActLO: J1.B11 (Door_Switch); also elsewhere on the board
FUEL_LVL_Rsense: J1.A7 (Fuel_level); also elsewhere on the board
GND: C1.1, C7.1, C8.1, C9.2, C10.1, C12.2, C50.1, D13.1 (K), D14.1 (K), D19.1 (K), H1.1, H3.1, H4.1, H5.1, H6.1, H7.1, J1.A2 (0V), J2.4, J5.3, J10.1, J11.4, J12.4, R91.1, R130.2, R138.1, R139.2, SW1.2, SW2.2, TP16.1, U1.2 (A1), U1.3 (A2), U1.12 (GND), U1.21 (A0), U2.1 (GND), U2.40 (GND), U2.41 (GND), U21.4 (VSS), U21.7 (WP); also elsewhere on the board
H_BEAM_ActHI: J1.A9 (Hi_Beam); also elsewhere on the board
IGNITION_ActHI: J1.A3 (Ignition), J2.3, J10.4; also elsewhere on the board
L_BEAM_ActHI: J1.B6 (Low_Beam); also elsewhere on the board
L_TURN_ActHI: D32.1 (K), J1.A11 (Left_Indicator), R132.1; also elsewhere on the board
unnamed: C12.1, R5.1, R6.2, R136.1, R137.1
unnamed: D13.2 (A), R100.2
unnamed: D14.2 (A), R101.2
unnamed: D19.2 (A), R89.2
unnamed: D20.1 (K), R92.1
unnamed: D21.1 (K), R97.1
unnamed: D31.2 (A), R133.2
unnamed: D32.2 (A), R134.1
unnamed: JP1.1 (A), R5.2, R136.2
unnamed: JP2.1 (A), R6.1, R137.2
unnamed: R93.1, R97.2
unnamed: R93.2, R131.1
unnamed: R132.2, R133.1
unnamed: R134.2, R135.1
OIL_ALRM_ActLO: J1.B3 (Oil_Pressure); also elsewhere on the board
PARK_ActLO: J1.B2 (Parking_Brake); also elsewhere on the board
Protected_12V: D20.2 (A), D21.2 (A), TP4.1; also elsewhere on the board
RPM_HALL: J1.A4 (RPM); also elsewhere on the board
R_TURN_ActHI: D31.1 (K), J1.A12 (Right_Indicator), R135.2; also elsewhere on the board
SPEED_HALL: J1.A5 (Speed); also elsewhere on the board
WATER_T_PWM: J1.A6 (Water_Temp); also elsewhere on the board

Notes on the sheet:
Address is 0x20
Full beams and button input used as early boot combinations to enter specific settings menu Hold until screens boot up
Rationale is to have : - latched - low profile - somewhat easy to DIY crimp with OTC pincers - 2A/pin (overkill)
2A Continuous output max
Isolated Harness I/O
Power supplies
BOOT/RESET buttons
ESP32 S3 module integration guidelines : - 90Ohm DP target for the USB, no crossing other signals - Capacitor buttons are optional - 10K pullup to EN with 1uF cap as per dev kit C 1.1 implementation - Reserved GPIOs (do not use) : 26->32 - Strapping IOs : 0-3-45-46
CANbus
Debug
Harness Connector
Display connectors
Load emulators
Sensors and FRAM
Pulse / PWM Schmitt + buffer

Parts:
C33, C34, C36: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C16194176
C35: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C100042
D5: 18V; D_SOD-123; LCSC C668896
R62: 39k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C163424
R63: 820k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C141684
R64: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22548
R65: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C105577
R66: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C105578
R67: 220k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C123420
TP8: ADS_VREF; TestPoint_Pad_D1.5mm
U19: ADS1115IDGS; TSSOP-10_3x3mm_P0.5mm; LCSC C37593

Connections:
+3V3: C33.1, R62.2, U19.7 (AIN3), U19.8 (VDD); also elsewhere on the board
/ANALOGUE/r_adc_1: U19.4 (AIN0); also elsewhere on the board
/ANALOGUE/v_ref: C34.2, R62.1, R63.1, TP8.1; also elsewhere on the board
/SCL: U19.10 (SCL); also elsewhere on the board
/SDA: U19.9 (SDA); also elsewhere on the board
GND: C33.2, C34.1, C35.1, C36.1, D5.2 (A), R63.2, R67.2, U19.1 (ADDR), U19.3 (GND); also elsewhere on the board
unnamed: C36.2, D5.1 (K), R65.1, R66.2
unnamed: R64.1, R66.1, R67.1
unnamed: C35.2, R64.2, U19.5 (AIN1)
Protected_12V: R65.2; also elsewhere on the board

Notes on the sheet:
Battery Measure From protected 12V
ADDR= 1001000b = 0x48
18.3 typ = 3.3V out
Analogue input circuits
Vref = 150mV

Parts:
R19: 8k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114637
R20: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C98220
U7: LTV-817S; SMDIP-4_W9.53mm; LCSC C109226

Connections:
+3V3: R20.1; also elsewhere on the board
/coolant: R20.2, U7.4; also elsewhere on the board
COOLANT_ActHI: R19.1; also elsewhere on the board
GND: U7.2, U7.3; also elsewhere on the board
unnamed: R19.2, U7.1

Parts of its further copies:
R31, R33, R35, R37, R39, R45: 8k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114637
R32, R34, R36, R38, R40, R46: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C98220
U13, U14, U15, U16, U17, U18: LTV-817S; SMDIP-4_W9.53mm; LCSC C109226

Connections of its further copies:
+3V3: R32.1, R34.1, R36.1, R38.1, R40.1, R46.1; also elsewhere on the board
/alarm: R46.2, U18.4; also elsewhere on the board
/backlight: R36.2, U15.4; also elsewhere on the board
/full_beams: R34.2, U14.4; also elsewhere on the board
/ignition: R40.2, U17.4; also elsewhere on the board
/left_turn: R32.2, U13.4; also elsewhere on the board
/right_turn: R38.2, U16.4; also elsewhere on the board
ALARM_ActHI: R45.1; also elsewhere on the board
GND: U13.2, U13.3, U14.2, U14.3, U15.2, U15.3, U16.2, U16.3, U17.2, U17.3, U18.2, U18.3; also elsewhere on the board
H_BEAM_ActHI: R33.1; also elsewhere on the board
IGNITION_ActHI: R39.1; also elsewhere on the board
L_BEAM_ActHI: R35.1; also elsewhere on the board
L_TURN_ActHI: R31.1; also elsewhere on the board
unnamed: R31.2, U13.1
unnamed: R33.2, U14.1
unnamed: R35.2, U15.1
unnamed: R37.2, U16.1
unnamed: R39.2, U17.1
unnamed: R45.2, U18.1
R_TURN_ActHI: R37.1; also elsewhere on the board

Notes on the sheet:
Single channel alternative : Diodes Inc DPC817S-B-TR
Assume 50% CTR w.c. Vf = 1.2V @1mA Lowest battery = 10V Circuit CTR: If = (10V-1.2V)/1mA = 8.8k. Lower closest 8k2 = 1.07mA Ic = 3.3/10k = 330uA CTRc = 0.33/1.07 = 30.8% Opto is always in saturation

Parts:
C30, C31: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C16194176
C32: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 10V; LCSC C87996
IC6: ATA6561; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2929602
R61: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17477

Connections:
+3V3: C30.1, IC6.5 (VIO); also elsewhere on the board
/LD_CAN_rx: IC6.4 (RXD); also elsewhere on the board
/LD_CAN_tx: IC6.1 (TXD); also elsewhere on the board
/Left Display CAN XCVR/V_SUPPLY: C31.1, C32.1, R61.2; also elsewhere on the board
CAN_H: IC6.7 (CAN_H); also elsewhere on the board
CAN_L: IC6.6 (CAN_L); also elsewhere on the board
GND: C30.2, C31.2, C32.2, IC6.2 (GND), IC6.8 (STBY); also elsewhere on the board
unnamed: IC6.3 (VCC), R61.1

Parts of its further copies:
C41, C42, C58, C59: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C16194176
C43, C60: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 10V; LCSC C87996
IC7, IC9: ATA6561; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2929602
R76, R88: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17477

Connections of its further copies:
+3V3: C41.1, C58.1, IC7.5 (VIO), IC9.5 (VIO); also elsewhere on the board
+5V: C59.1, C60.1, R88.2; also elsewhere on the board
/CAN_rx: IC9.4 (RXD); also elsewhere on the board
/CAN_tx: IC9.1 (TXD); also elsewhere on the board
/RD_CAN_rx: IC7.4 (RXD); also elsewhere on the board
/RD_CAN_tx: IC7.1 (TXD); also elsewhere on the board
/Right Display CAN XCVR/V_SUPPLY: C42.1, C43.1, R76.2; also elsewhere on the board
CAN_H: IC7.7 (CAN_H), IC9.7 (CAN_H); also elsewhere on the board
CAN_L: IC7.6 (CAN_L), IC9.6 (CAN_L); also elsewhere on the board
GND: C41.2, C42.2, C43.2, C58.2, C59.2, C60.2, IC7.2 (GND), IC7.8 (STBY), IC9.2 (GND), IC9.8 (STBY); also elsewhere on the board
unnamed: IC7.3 (VCC), R76.1
unnamed: IC9.3 (VCC), R88.1

Notes on the sheet:
Internal pull-up. Pull low to enable!
0R resistor added for convenience and pin-compatibility with other transceivers.

Parts:
R11: 8k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114637
R12: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C98220
U3: LTV-817S; SMDIP-4_W9.53mm; LCSC C109226

Connections:
+3V3: R12.1; also elsewhere on the board
/oil: R12.2, U3.4; also elsewhere on the board
GND: U3.3; also elsewhere on the board
unnamed: R11.2, U3.1
OIL_ALRM_ActLO: U3.2; also elsewhere on the board
Protected_12V: R11.1; also elsewhere on the board

Parts of its further copies:
R13, R15, R17, R21, R23, R25, R27, R29: 8k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114637
R14, R16, R18, R22, R24, R26, R28, R30: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C98220
U4, U5, U6, U8, U9, U10, U11, U12: LTV-817S; SMDIP-4_W9.53mm; LCSC C109226

Connections of its further copies:
+3V3: R14.1, R16.1, R18.1, R22.1, R24.1, R26.1, R28.1, R30.1; also elsewhere on the board
/abs: R24.2, U9.4; also elsewhere on the board
/airbag: R14.2, U4.4; also elsewhere on the board
/alternator: R30.2, U12.4; also elsewhere on the board
/brakes: R28.2, U11.4; also elsewhere on the board
/button: R18.2, U6.4; also elsewhere on the board
/cel: R16.2, U5.4; also elsewhere on the board
/door: R22.2, U8.4; also elsewhere on the board
/parking: R26.2, U10.4; also elsewhere on the board
ABS_ActLO: U9.2; also elsewhere on the board
AIRBAG_ActLO: U4.2; also elsewhere on the board
ALTERN_ActLO: U12.2; also elsewhere on the board
BRAKE_ActLO: U11.2; also elsewhere on the board
BTN_ActLO: U6.2; also elsewhere on the board
CEL_ActLO: U5.2; also elsewhere on the board
DOOR_ActLO: U8.2; also elsewhere on the board
GND: U4.3, U5.3, U6.3, U8.3, U9.3, U10.3, U11.3, U12.3; also elsewhere on the board
unnamed: R13.2, U4.1
unnamed: R15.2, U5.1
unnamed: R17.2, U6.1
unnamed: R21.2, U8.1
unnamed: R23.2, U9.1
unnamed: R25.2, U10.1
unnamed: R27.2, U11.1
unnamed: R29.2, U12.1
PARK_ActLO: U10.2; also elsewhere on the board
Protected_12V: R13.1, R15.1, R17.1, R21.1, R23.1, R25.1, R27.1, R29.1; also elsewhere on the board

Notes on the sheet:
Assume 50% CTR w.c. Vf = 1.2V @1mA Lowest battery = 10V Circuit CTR: If = (10V-1.2V)/1mA = 8.8k. Lower closest 8k2 = 1.07mA Ic = 3.3/10k = 330uA CTRc = 0.33/1.07 = 30.8% Opto is always in saturation
Single channel alternative : Diodes Inc DPC817S-B-TR

Parts:
C20: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 25V; LCSC C14860
C21, C22, C24: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C16194176
C23: 22p; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder; Voltage 50V; LCSC C1882706; not fitted
C25, C26: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 10V; LCSC C87996
IC3: AP62200; TSOT-23-6_HandSoldering; LCSC C1323282
L2: 3u3; L_Taiyo-Yuden_NR-50xx_HandSoldering; LCSC C28642360
R41: 820k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C141684
R42: 120k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114607
R43: 75k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114636
R44: 24k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C137760

Connections:
+3V3: C23.1, C24.2, C25.1, C26.1, L2.2, R43.1; also elsewhere on the board
/3V3_SMPS/3V3_EN: IC3.5 (EN), R41.2, R42.1
/3V3_SMPS/3V3_FB: C23.2, IC3.4 (FB), R43.2, R44.1
/3V3_SMPS/3V3_SW: C22.1, IC3.2 (SW), L2.1
GND: C20.1, C21.1, C24.1, C25.2, C26.2, IC3.1 (GND), R42.2, R44.2; also elsewhere on the board
unnamed: C22.2, IC3.6 (BST)
Protected_12V: C20.2, C21.2, IC3.3 (VIN), R41.1; also elsewhere on the board

Notes on the sheet:
Ven = 1.2V type. 1.25V max Must enable at 10V. Rtop = 820k, Rbtm = 120k. Ven = 9.4V @1.2V typ., ~9.8V @1.25V max.
Vfb = 0.8V, +/-2% w.c. Rtop = 75k, Rbtm = 24k 3.3V out typ. min ~3.22V, max ~3.38V
