# Repository martinroger/VXDash (continued)

## KiCad design KiCad PCB Files/VXDash_RemoteECU/VXDash_RemoteECU.kicad_pcb

Parts:
C1, C2, C4: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 25V
C3: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V
IC1: CD74HC4050M96; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C131932
J1: UART0 debug; PinHeader_1x04_P2.54mm_Vertical; not fitted
J2: CANbus IN; DT13-4P_TE_Deutsch
J3: I²C debug; PinHeader_1x03_P2.54mm_Vertical; not fitted
J4: Outputs; QT04ASFxxH
J5: Digital ActiveLows; QT04ASFxxH
J6: Digital ActiveHighs; QT04ASFxxH
J7: Sensor 5V; QT04ASFxxH
J8: Sensor 0V; QT04ASFxxH
J9: Analogue_V; QT04ASFxxH
J10: Analogue_R; QT04ASFxxH
J11: PWM inputs; QT04ASFxxH
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R6: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8, R9, R10: R; R_0603_1608Metric
R11, R12, R13: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RESET; SW_Push_1P1T_NO_LED_E-Switch_TL1250
SW2: BOOT; SW_Push_1P1T_NO_LED_E-Switch_TL1250
U1: ESP32-S3-WROOM-1

Connections:
3V3: C1.2, C2.2, C4.2, IC1.1 (VCC), J1.1, R3.1, R4.2, R5.2, R6.2; also elsewhere on the board
/5V_EN: U1.25 (GPIO48/SPICLK_N/SUBSPICLK_N_DIFF); also elsewhere on the board
/AnaR_1: J10.1; also elsewhere on the board
/AnaR_2: J10.2; also elsewhere on the board
/AnaR_3: J10.3; also elsewhere on the board
/AnaR_4: J10.4; also elsewhere on the board
/AnaV_1: J9.1; also elsewhere on the board
/AnaV_2: J9.2; also elsewhere on the board
/AnaV_3: J9.3; also elsewhere on the board
/AnaV_4: J9.4; also elsewhere on the board
/BOOT: R2.1, U1.27 (GPIO0/BOOT)
/CAN_Rx: U1.11 (GPIO18/U1RXD/ADC2_CH7/CLK_OUT3); also elsewhere on the board
/CAN_Tx: U1.10 (GPIO17/U1TXD/ADC2_CH6); also elsewhere on the board
/Input protection/Power_0V: J2.1; also elsewhere on the board
/Low-side Outputs/Output1: J4.1; also elsewhere on the board
/Low-side Outputs/Output2: J4.2; also elsewhere on the board
/Low-side Outputs/Output3: J4.3; also elsewhere on the board
/Low-side Outputs/Output4: J4.4; also elsewhere on the board
/Opto 4xActiveHigh/HL_Input1: J6.1; also elsewhere on the board
/Opto 4xActiveHigh/HL_Input2: J6.2; also elsewhere on the board
/Opto 4xActiveHigh/HL_Input3: J6.3; also elsewhere on the board
/Opto 4xActiveHigh/HL_Input4: J6.4; also elsewhere on the board
/Opto 4xActiveLow/~HL_Input1: J5.1; also elsewhere on the board
/Opto 4xActiveLow/~HL_Input2: J5.2; also elsewhere on the board
/Opto 4xActiveLow/~HL_Input3: J5.3; also elsewhere on the board
/Opto 4xActiveLow/~HL_Input4: J5.4; also elsewhere on the board
/OutCtrl1: U1.17 (GPIO9/TOUCH9/ADC1_CH8/FSPIHD/SUBSPIHD); also elsewhere on the board
/OutCtrl2: U1.18 (GPIO10/TOUCH10/ADC1_CH9/FSPICS0/FSPIIO4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); also elsewhere on the board
/OutCtrl3: U1.19 (GPIO11/TOUCH11/ADC2_CH0/FSPID/FSPIIO5/S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); also elsewhere on the board
/OutCtrl4: U1.20 (GPIO12/TOUCH12/ADC2_CH1/FSPICLK/FSPIIO6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); also elsewhere on the board
/PWM_cap_0: IC1.3 (1A), J11.1
/PWM_cap_1: IC1.5 (2A), J11.2
/PWM_cap_2: IC1.7 (3A), J11.3
/SCL: J3.1, R6.1, U1.4 (GPIO4/TOUCH4/ADC1_CH3); also elsewhere on the board
/SDA: J3.2, R5.1, U1.5 (GPIO5/TOUCH5/ADC1_CH4); also elsewhere on the board
/Switched_12V: J2.4; also elsewhere on the board
/UART0_Rx: J1.3, U1.36 (U0RXD/GPIO44/CLK_OUT2)
/UART0_Tx: J1.2, U1.37 (U0TXD/GPIO43/CLK_OUT1)
/USB_DN: U1.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-); also elsewhere on the board
/USB_DP: U1.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+); also elsewhere on the board
/esp32_enable: C3.2, R1.2, R3.2, U1.3 (EN)
/mcpwm_cap_0: R11.1, U1.28 (SPIIO6/GPIO35/FSPID/SUBSPID)
/mcpwm_cap_1: R12.1, U1.29 (SPIIO7/GPIO36/FSPICLK/SUBSPICLK)
/mcpwm_cap_2: R13.1, U1.30 (SPIDQS/GPIO37/FSPIQ/SUBSPIQ)
/set_r_range_1: U1.21 (GPIO13/TOUCH13/ADC2_CH2/FSPIQ/FSPIIO7/S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); also elsewhere on the board
/set_r_range_2: U1.22 (GPIO14/TOUCH14/ADC2_CH3/FSPIWP/FSPIDQS/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); also elsewhere on the board
/set_r_range_3: U1.23 (GPIO21); also elsewhere on the board
/set_r_range_4: U1.24 (GPIO47/SPICLK_P/SUBSPICLK_P_DIFF); also elsewhere on the board
/~ActiHigh1: U1.32 (MTCK/GPIO39/CLK_OUT3/SUBSPICS1); also elsewhere on the board
/~ActiHigh2: U1.33 (MTDO/GPIO40/CLK_OUT2); also elsewhere on the board
/~ActiHigh3: U1.34 (MTDI/GPIO41/CLK_OUT1); also elsewhere on the board
/~ActiHigh4: U1.35 (MTMS/GPIO42); also elsewhere on the board
/~ActiLow1: U1.6 (GPIO6/TOUCH6/ADC1_CH5); also elsewhere on the board
/~ActiLow2: U1.7 (GPIO7/TOUCH7/ADC1_CH6); also elsewhere on the board
/~ActiLow3: U1.8 (GPIO15/U0RTS/ADC2_CH4/XTAL_32K_P); also elsewhere on the board
/~ActiLow4: U1.9 (GPIO16/U0CTS/ADC2_CH5/XTAL_32K_N); also elsewhere on the board
CAN_H: J2.3; also elsewhere on the board
CAN_L: J2.2; also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.1, IC1.8 (GND), IC1.9 (4A), IC1.11 (5A), IC1.14 (6A), J1.4, J3.3, J8.1, J8.2, J8.3, J8.4, J11.4, SW1.2, SW2.2, U1.1 (GND), U1.40 (GND), U1.41 (GND); also elsewhere on the board
unnamed: IC1.2 (1Y), R11.2
unnamed: IC1.4 (2Y), R12.2
unnamed: IC1.6 (3Y), R13.2
unnamed: J7.1, R7.2
unnamed: J7.2, R8.2
unnamed: J7.3, R9.2
unnamed: J7.4, R10.2
unnamed: R1.1, SW1.1
unnamed: R2.2, SW2.1
unnamed: R4.1, U1.2 (3V3)

Notes on the sheet:
50mA max consumption
Dash CAN Interface
Avoid GPIO0, GPIO3, GPIO45, GPIO46 on ESP32-S3 as they're strap sampled at boot.
Analogue inputs
BOOT/RESET buttons
Digital inputs
Connector & Power
Outputs
VXDash RemoteECU Features: - 4x Analogue resistive sensor inputs. - 4x Analogue voltage sensor inputs. - 3x PWM sensor inputs. - 8x Digital inputs. (4x active high, 4x active low). - 4x Outputs. (low-side driver) - CAN interface (comms to main VXDash). TODO: - Explore simultaneous sampling ADC inst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
Pulse / PWM buffer

Parts:
C28, C29: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 25V
C30: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V
R47: 39k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R48: 820k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U5, U6: ADS1115IDGS; TSSOP-10_3x3mm_P0.5mm

Connections:
/Analogue/r_adc_1: U6.4 (AIN0); also elsewhere on the board
/Analogue/r_adc_2: U6.5 (AIN1); also elsewhere on the board
/Analogue/r_adc_3: U6.6 (AIN2); also elsewhere on the board
/Analogue/r_adc_4: U6.7 (AIN3); also elsewhere on the board
/Analogue/v_adc_1: U5.4 (AIN0); also elsewhere on the board
/Analogue/v_adc_2: U5.5 (AIN1); also elsewhere on the board
/Analogue/v_adc_3: U5.6 (AIN2); also elsewhere on the board
/Analogue/v_adc_4: U5.7 (AIN3); also elsewhere on the board
/Analogue/v_ref: C30.2, R47.1, R48.1; also elsewhere on the board
/SCL: U5.10 (SCL), U6.10 (SCL); also elsewhere on the board
/SDA: U5.9 (SDA), U6.9 (SDA); also elsewhere on the board
GND: C28.1, C29.1, C30.1, R48.2, U5.1 (ADDR), U5.3 (GND), U6.3 (GND); also elsewhere on the board

Notes on the sheet:
ADDR= 1001000b = 0x48
Using 5V VDD to remove need of an input divider.
ADDR= 1001001b = 0x49
Vref = 150mV
Analogue input circuits

Parts:
R24, R26: 8k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R25, R27, R28, R30: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R29, R31: 8k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C114637
U2: LTV-847S; SMDIP-16_W9.53mm

Connections:
3V3: R25.1, R27.1, R28.1, R30.1; also elsewhere on the board
/Opto 4xActiveLow/~HL_Input1: U2.2; also elsewhere on the board
/Opto 4xActiveLow/~HL_Input2: U2.4; also elsewhere on the board
/Opto 4xActiveLow/~HL_Input3: U2.6; also elsewhere on the board
/Opto 4xActiveLow/~HL_Input4: U2.8; also elsewhere on the board
/~ActiLow1: R25.2, U2.16; also elsewhere on the board
/~ActiLow2: R27.2, U2.14; also elsewhere on the board
/~ActiLow3: R28.2, U2.12; also elsewhere on the board
/~ActiLow4: R30.2, U2.10; also elsewhere on the board
GND: U2.9, U2.11, U2.13, U2.15; also elsewhere on the board
unnamed: R24.2, U2.1
unnamed: R26.2, U2.3
unnamed: R29.2, U2.5
unnamed: R31.2, U2.7
Protected_12V: R24.1, R26.1, R29.1, R31.1

Notes on the sheet:
Active-low input optoisolators. Inputs to chassis 0V. Assume 50% CTR w.c. Vf = 1.2V @1mA Lowest battery = 10V Circuit CTR: If = (10V-1.2V)/1mA = 8.8k. Lower closest 8k2 = 1.07mA Ic = 3.3/10k = 330uA CTRc = 0.33/1.07 = 30.8% Opto is always in saturation

Parts:
D2: SP0503BAHTG; SOT-143; Manufacturer_Part_Number SP0503BAHTG
J12: USB4105-GF-A; GCT_USB4105-GF-A
R40, R41: 5.1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
/USB C/VBUS: D2.2 (K), J12.A4_B9 (VBUS), J12.B4_A9 (VBUS__1)
/USB_DN: D2.4 (K), J12.A7 (DN1), J12.B7 (DN2); also elsewhere on the board
/USB_DP: D2.3 (K), J12.A6 (DP1), J12.B6 (DP2); also elsewhere on the board
GND: D2.1 (A), J12.A1_B12 (GND), J12.B1_A12 (GND__1), J12.SH1 (SHELL_GND), J12.SH2 (SHELL_GND__1), J12.SH3 (SHELL_GND__2), J12.SH4 (SHELL_GND__3), R40.1, R41.2; also elsewhere on the board
unnamed: J12.A5 (CC1), R40.2
unnamed: J12.B5 (CC2), R41.1

Parts:
C41, C42, C43: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 25V
C44: 4n7; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; LCSC C106218
IC7: ATA6561; SOIC-8_3.9x4.9mm_P1.27mm
R81: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R82, R83, R84, R85: 120R; R_0603_1608Metric

Connections:
3V3: C41.2, IC7.5 (VIO); also elsewhere on the board
/CAN_Rx: IC7.4 (RXD); also elsewhere on the board
/CAN_Tx: IC7.1 (TXD); also elsewhere on the board
CAN_H: IC7.7 (CAN_H), R82.2, R83.2; also elsewhere on the board
CAN_L: IC7.6 (CAN_L), R84.1, R85.1; also elsewhere on the board
GND: C41.1, C42.1, C43.1, C44.1, IC7.2 (GND), IC7.8 (STBY); also elsewhere on the board
unnamed: C44.2, R82.1, R83.1, R84.2, R85.2
unnamed: IC7.3 (VCC), R81.1

Notes on the sheet:
Internal pull-up. Pull low to enable!

Parts:
R32, R34, R36, R38: 8k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R33, R35, R37, R39: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U3: LTV-847S; SMDIP-16_W9.53mm

Connections:
3V3: R33.1, R35.1, R37.1, R39.1; also elsewhere on the board
/Opto 4xActiveHigh/HL_Input1: R32.1; also elsewhere on the board
/Opto 4xActiveHigh/HL_Input2: R34.1; also elsewhere on the board
/Opto 4xActiveHigh/HL_Input3: R36.1; also elsewhere on the board
/Opto 4xActiveHigh/HL_Input4: R38.1; also elsewhere on the board
/~ActiHigh1: R33.2, U3.16; also elsewhere on the board
/~ActiHigh2: R35.2, U3.14; also elsewhere on the board
/~ActiHigh3: R37.2, U3.12; also elsewhere on the board
/~ActiHigh4: R39.2, U3.10; also elsewhere on the board
GND: U3.2, U3.4, U3.6, U3.8, U3.9, U3.11, U3.13, U3.15; also elsewhere on the board
unnamed: R32.2, U3.1
unnamed: R34.2, U3.3
unnamed: R36.2, U3.5
unnamed: R38.2, U3.7

Notes on the sheet:
Active-high input optoisolators. 12V inputs Assume 50% CTR w.c. Vf = 1.2V @1mA Lowest battery = 10V Circuit CTR: If = (10V-1.2V)/1mA = 8.8k. Lower closest 8k2 = 1.07mA Ic = 3.3/10k = 330uA CTRc = 0.33/1.07 = 30.8% Opto is always in saturation

Parts:
C23: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 25V
F2, F3, F4, F5: Mini blade 1A; Fuseholder_Blade_Mini_Keystone_3568
U4: TPL7407LAPW; TSSOP-16_4.4x5mm_P0.65mm

Connections:
/Low-side Outputs/Output1: F2.1; also elsewhere on the board
/Low-side Outputs/Output2: F3.1; also elsewhere on the board
/Low-side Outputs/Output3: F4.1; also elsewhere on the board
/Low-side Outputs/Output4: F5.1; also elsewhere on the board
/OutCtrl1: U4.1 (IN1), U4.2 (IN2); also elsewhere on the board
/OutCtrl2: U4.3 (IN3), U4.4 (IN4); also elsewhere on the board
/OutCtrl3: U4.5 (IN5), U4.6 (IN6); also elsewhere on the board
/OutCtrl4: U4.7 (IN7); also elsewhere on the board
/Protected_12V: C23.2, U4.9 (COM); also elsewhere on the board
GND: C23.1, U4.8 (GND); also elsewhere on the board
unnamed: F2.2, U4.15 (OUT2), U4.16 (OUT1)
unnamed: F3.2, U4.13 (OUT4), U4.14 (OUT3)
unnamed: F4.2, U4.11 (OUT6), U4.12 (OUT5)
unnamed: F5.2, U4.10 (OUT7)

Notes on the sheet:
4 Channel low-side driver Outputs 1-3 are parallel driven to reduce stress on the driver and increase drive capability. Output 4 will be a low current output.

Parts:
C15, C16, C17, C18: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Voltage 50V
F1: 0ZRB0250FF1E; Fuse_BelFuse_0ZRE0033FF_L11.4mm_W3.8mm
R18, R21: 0R; R_0805_2012Metric
RV1: MOV-07D220K; RV_Disc_D9mm_W3.5mm_P5mm

Connections:
/Input protection/Power_0V: C15.1, C16.1, R21.1, RV1.1; also elsewhere on the board
/Input protection/Power_Fused: C15.2, C16.2, F1.2, R18.1, RV1.2
/Protected_12V: C17.2, C18.2, R18.2; also elsewhere on the board
/Switched_12V: F1.1; also elsewhere on the board
GND: C17.1, C18.1, R21.2; also elsewhere on the board

Notes on the sheet:
Voltage spike protection. Automotive 12V supply can see spikes >60V due to load-dump, etc. Varistor 18V max working, 24V max clamping 250A.
0ZRB0250FF1E 2.5A Hold max 5A trip 10.3s time-to-trip

Schematic: 3V3_SMPS.kicad_sch, VXDash RemoteECU

Parts:
C5: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V
C6, C7: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 25V
C8: 22p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; not fitted
C10, C11: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 10V
IC2: AP62200; TSOT-23-6_HandSoldering
L1: 3u3; L_Taiyo-Yuden_NR-50xx_HandSoldering
R14: 820k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 75k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 120k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 24k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
3V3: C8.1, C10.1, C11.1, L1.2, R15.1; also elsewhere on the board
/Protected_12V: C6.2, C7.2, IC2.3 (VIN), R14.1; also elsewhere on the board
GND: C6.1, C7.1, C10.2, C11.2, IC2.1 (GND), R16.2, R17.2; also elsewhere on the board
unnamed: C5.2, IC2.6 (BST)
unnamed: IC2.5 (EN), R14.2, R16.1
unnamed: C8.2, IC2.4 (FB), R15.2, R17.1
unnamed: C5.1, IC2.2 (SW), L1.1

Notes on the sheet:
Ven = 1.2V type. 1.25V max Must enable at 10V. Rtop = 820k, Rbtm = 120k. Ven = 9.4V @1.2V typ., ~9.8V @1.25V max.
Vfb = 0.8V, +/-2% w.c. Rtop = 75k, Rbtm = 24k 3.3V out typ. min ~3.22V, max ~3.38V

Schematic: 5V_SMPS.kicad_sch, VXDash RemoteECU

Parts:
C12: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V
C13, C14: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 25V
C19: 22p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; not fitted
C20, C21: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 10V
IC3: AP62200; TSOT-23-6_HandSoldering
L2: 4u7; Ind_5050
R19: 43k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20: 130k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R22: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23: 8k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
/5V_EN: R20.2; also elsewhere on the board
/Protected_12V: C13.2, C14.2, IC3.3 (VIN); also elsewhere on the board
GND: C13.1, C14.1, C20.2, C21.2, IC3.1 (GND), R22.2, R23.2; also elsewhere on the board
unnamed: C12.2, IC3.6 (BST)
unnamed: IC3.5 (EN), R20.1, R22.1
unnamed: C19.2, IC3.4 (FB), R19.2, R23.1
unnamed: C12.1, IC3.2 (SW), L2.1

Notes on the sheet:
Vfb = 0.8V, +/-2% w.c. Rtop = 43k, Rbtm = 8k2 4.995V out typ. min ~4.86V, max ~5.12V
EN from 3V3 MCU pin. Quicker turn off as 3V3 falls. Rising threshold = 2.76 typ, ~3V max Falling threshold = 2.53 typ, ~2.3V min

Schematic: Rsensing_Pair.kicad_sch, VXDash RemoteECU

Parts:
C9: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 25V
C36, C37: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V
D7, D9: BAT54; D_SOD-123
D8, D10: BAV199; SOT-23-3
IC4: AS2333_OpAmp; MSOP-8_3x3mm_P0.65mm
Q1, Q2, Q3, Q4: DMP3099L; SOT-23
R53, R55: 18R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R54, R56: 160R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R57, R59: 6R8; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R58, R60, R63, R64: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R61, R62: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R65, R66: 1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder

Connections:
/AnaR_1: D7.1 (K), R65.1; also elsewhere on the board
/AnaR_2: D9.1 (K), R66.1; also elsewhere on the board
/Analogue/r_adc_1: C36.2, D8.3 (K), R65.2; also elsewhere on the board
/Analogue/r_adc_2: C37.2, D10.3 (K), R66.2; also elsewhere on the board
/Analogue/v_ref: IC4.2 (-), IC4.6 (-); also elsewhere on the board
/set_r_range_1: R58.1; also elsewhere on the board
/set_r_range_2: R60.1; also elsewhere on the board
GND: C9.1, C36.1, C37.1, D8.1 (A), D10.1 (A), IC4.4; also elsewhere on the board
unnamed: D7.2 (A), Q3.3 (D)
unnamed: D9.2 (A), Q4.3 (D)
unnamed: IC4.1, R63.1
unnamed: IC4.7, R64.1
unnamed: IC4.3 (+), Q3.2 (S), R61.1
unnamed: IC4.5 (+), Q4.2 (S), R62.1
unnamed: Q1.3 (D), R59.1, R61.2
unnamed: Q1.1 (G), R58.2
unnamed: Q1.2 (S), R53.1
unnamed: Q2.3 (D), R57.1, R62.2
unnamed: Q2.1 (G), R60.2
unnamed: Q2.2 (S), R55.1
unnamed: Q3.1 (G), R63.2
unnamed: Q4.1 (G), R64.2
unnamed: R54.1, R59.2
unnamed: R56.1, R57.2

Parts of its further copies:
C35: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 25V
D11, D13: BAT54; D_SOD-123
D12, D14: BAV199; SOT-23-3
IC6: AS2333_OpAmp; MSOP-8_3x3mm_P0.65mm
Q5, Q6, Q7, Q8: DMP3099L; SOT-23
R67, R69: 18R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R68, R70: 160R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R71, R73: 6R8; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R72, R74, R77, R78: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R75, R76: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R79, R80: 1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder

Connections of its further copies:
/AnaR_3: D11.1 (K), R79.1; also elsewhere on the board
/AnaR_4: D13.1 (K), R80.1; also elsewhere on the board
/Analogue/r_adc_3: D12.3 (K), R79.2; also elsewhere on the board
/Analogue/r_adc_4: D14.3 (K), R80.2; also elsewhere on the board
/Analogue/v_ref: IC6.2 (-), IC6.6 (-); also elsewhere on the board
/set_r_range_3: R72.1; also elsewhere on the board
/set_r_range_4: R74.1; also elsewhere on the board
GND: C35.1, D12.1 (A), D14.1 (A), IC6.4; also elsewhere on the board
unnamed: D11.2 (A), Q7.3 (D)
unnamed: D13.2 (A), Q8.3 (D)
unnamed: IC6.1, R77.1
unnamed: IC6.7, R78.1
unnamed: IC6.3 (+), Q7.2 (S), R75.1
unnamed: IC6.5 (+), Q8.2 (S), R76.1
unnamed: Q5.3 (D), R73.1, R75.2
unnamed: Q5.1 (G), R72.2
unnamed: Q5.2 (S), R67.1
unnamed: Q6.3 (D), R71.1, R76.2
unnamed: Q6.1 (G), R74.2
unnamed: Q6.2 (S), R69.1
unnamed: Q7.1 (G), R77.2
unnamed: Q8.1 (G), R78.2
unnamed: R68.1, R73.2
unnamed: R70.1, R71.2

Notes on the sheet:
Place cap near ADC
Zener required on the 3V3 rail. Put Zener closer to the Rsensing circuits.
ADC range 2.7V. Allows for reasonable voltage drop across current source and diode. 300R and 3k max sensor resistance per range. Low range = 2.7 / 300 = 9mA, High range = 2.7 / 3k = 900uA. 150mV Vref. Low range = 150mV / 9mA = 16.666 ohm High range 150mA / 900uA = 166.666 ohm High range = 160R + 6R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
